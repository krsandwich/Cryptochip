$ Spice netlist generated by v2lvs
$ v2013.2_18.13    Thu May 16 11:29:55 PDT 2013
.INCLUDE "inputs/adk/stdcells.spi"

.SUBCKT RAM32 CLK EN VPWR VGND A[4] A[3] A[2] A[1] A[0] Di[31] Di[30] Di[29]
+ Di[28] Di[27] Di[26] Di[25] Di[24] Di[23] Di[22] Di[21] Di[20] Di[19] Di[18]
+ Di[17] Di[16] Di[15] Di[14] Di[13] Di[12] Di[11] Di[10] Di[9] Di[8] Di[7]
+ Di[6] Di[5] Di[4] Di[3] Di[2] Di[1] Di[0] Do[31] Do[30] Do[29] Do[28] Do[27]
+ Do[26] Do[25] Do[24] Do[23] Do[22] Do[21] Do[20] Do[19] Do[18] Do[17] Do[16]
+ Do[15] Do[14] Do[13] Do[12] Do[11] Do[10] Do[9] Do[8] Do[7] Do[6] Do[5] Do[4]
+ Do[3] Do[2] Do[1] Do[0] WE[3] WE[2] WE[1] WE[0]
XABUF[0] A[0] VGND VGND VPWR VPWR SLICE[0].RAM8x32.A[0]
+ sky130_fd_sc_hd__clkbuf_2
XABUF[1] A[1] VGND VGND VPWR VPWR SLICE[0].RAM8x32.A[1]
+ sky130_fd_sc_hd__clkbuf_2
XABUF[2] A[2] VGND VGND VPWR VPWR SLICE[0].RAM8x32.A[2]
+ sky130_fd_sc_hd__clkbuf_2
XABUF[3] A[3] VGND VGND VPWR VPWR DEC.A[0] sky130_fd_sc_hd__clkbuf_2
XABUF[4] A[4] VGND VGND VPWR VPWR DEC.A[1] sky130_fd_sc_hd__clkbuf_2
XCLKBUF CLK VGND VGND VPWR VPWR SLICE[0].RAM8x32.CLK sky130_fd_sc_hd__clkbuf_2
XDEC.AND0 DEC.A[0] DEC.A[1] DEC.EN VGND VGND VPWR VPWR SLICE[0].RAM8x32.DEC.EN
+ sky130_fd_sc_hd__nor3b_4
XDEC.AND1 DEC.A[1] DEC.A[0] DEC.EN VGND VGND VPWR VPWR SLICE[1].RAM8x32.DEC.EN
+ sky130_fd_sc_hd__and3b_4
XDEC.AND2 DEC.A[0] DEC.A[1] DEC.EN VGND VGND VPWR VPWR SLICE[2].RAM8x32.DEC.EN
+ sky130_fd_sc_hd__and3b_4
XDEC.AND3 DEC.A[1] DEC.A[0] DEC.EN VGND VGND VPWR VPWR SLICE[3].RAM8x32.DEC.EN
+ sky130_fd_sc_hd__and3_4
XDIBUF[0] Di[0] VGND VGND VPWR VPWR SLICE[0].RAM8x32.Di[0]
+ sky130_fd_sc_hd__clkbuf_16
XDIBUF[10] Di[10] VGND VGND VPWR VPWR SLICE[0].RAM8x32.Di[10]
+ sky130_fd_sc_hd__clkbuf_16
XDIBUF[11] Di[11] VGND VGND VPWR VPWR SLICE[0].RAM8x32.Di[11]
+ sky130_fd_sc_hd__clkbuf_16
XDIBUF[12] Di[12] VGND VGND VPWR VPWR SLICE[0].RAM8x32.Di[12]
+ sky130_fd_sc_hd__clkbuf_16
XDIBUF[13] Di[13] VGND VGND VPWR VPWR SLICE[0].RAM8x32.Di[13]
+ sky130_fd_sc_hd__clkbuf_16
XDIBUF[14] Di[14] VGND VGND VPWR VPWR SLICE[0].RAM8x32.Di[14]
+ sky130_fd_sc_hd__clkbuf_16
XDIBUF[15] Di[15] VGND VGND VPWR VPWR SLICE[0].RAM8x32.Di[15]
+ sky130_fd_sc_hd__clkbuf_16
XDIBUF[16] Di[16] VGND VGND VPWR VPWR SLICE[0].RAM8x32.Di[16]
+ sky130_fd_sc_hd__clkbuf_16
XDIBUF[17] Di[17] VGND VGND VPWR VPWR SLICE[0].RAM8x32.Di[17]
+ sky130_fd_sc_hd__clkbuf_16
XDIBUF[18] Di[18] VGND VGND VPWR VPWR SLICE[0].RAM8x32.Di[18]
+ sky130_fd_sc_hd__clkbuf_16
XDIBUF[19] Di[19] VGND VGND VPWR VPWR SLICE[0].RAM8x32.Di[19]
+ sky130_fd_sc_hd__clkbuf_16
XDIBUF[1] Di[1] VGND VGND VPWR VPWR SLICE[0].RAM8x32.Di[1]
+ sky130_fd_sc_hd__clkbuf_16
XDIBUF[20] Di[20] VGND VGND VPWR VPWR SLICE[0].RAM8x32.Di[20]
+ sky130_fd_sc_hd__clkbuf_16
XDIBUF[21] Di[21] VGND VGND VPWR VPWR SLICE[0].RAM8x32.Di[21]
+ sky130_fd_sc_hd__clkbuf_16
XDIBUF[22] Di[22] VGND VGND VPWR VPWR SLICE[0].RAM8x32.Di[22]
+ sky130_fd_sc_hd__clkbuf_16
XDIBUF[23] Di[23] VGND VGND VPWR VPWR SLICE[0].RAM8x32.Di[23]
+ sky130_fd_sc_hd__clkbuf_16
XDIBUF[24] Di[24] VGND VGND VPWR VPWR SLICE[0].RAM8x32.Di[24]
+ sky130_fd_sc_hd__clkbuf_16
XDIBUF[25] Di[25] VGND VGND VPWR VPWR SLICE[0].RAM8x32.Di[25]
+ sky130_fd_sc_hd__clkbuf_16
XDIBUF[26] Di[26] VGND VGND VPWR VPWR SLICE[0].RAM8x32.Di[26]
+ sky130_fd_sc_hd__clkbuf_16
XDIBUF[27] Di[27] VGND VGND VPWR VPWR SLICE[0].RAM8x32.Di[27]
+ sky130_fd_sc_hd__clkbuf_16
XDIBUF[28] Di[28] VGND VGND VPWR VPWR SLICE[0].RAM8x32.Di[28]
+ sky130_fd_sc_hd__clkbuf_16
XDIBUF[29] Di[29] VGND VGND VPWR VPWR SLICE[0].RAM8x32.Di[29]
+ sky130_fd_sc_hd__clkbuf_16
XDIBUF[2] Di[2] VGND VGND VPWR VPWR SLICE[0].RAM8x32.Di[2]
+ sky130_fd_sc_hd__clkbuf_16
XDIBUF[30] Di[30] VGND VGND VPWR VPWR SLICE[0].RAM8x32.Di[30]
+ sky130_fd_sc_hd__clkbuf_16
XDIBUF[31] Di[31] VGND VGND VPWR VPWR SLICE[0].RAM8x32.Di[31]
+ sky130_fd_sc_hd__clkbuf_16
XDIBUF[3] Di[3] VGND VGND VPWR VPWR SLICE[0].RAM8x32.Di[3]
+ sky130_fd_sc_hd__clkbuf_16
XDIBUF[4] Di[4] VGND VGND VPWR VPWR SLICE[0].RAM8x32.Di[4]
+ sky130_fd_sc_hd__clkbuf_16
XDIBUF[5] Di[5] VGND VGND VPWR VPWR SLICE[0].RAM8x32.Di[5]
+ sky130_fd_sc_hd__clkbuf_16
XDIBUF[6] Di[6] VGND VGND VPWR VPWR SLICE[0].RAM8x32.Di[6]
+ sky130_fd_sc_hd__clkbuf_16
XDIBUF[7] Di[7] VGND VGND VPWR VPWR SLICE[0].RAM8x32.Di[7]
+ sky130_fd_sc_hd__clkbuf_16
XDIBUF[8] Di[8] VGND VGND VPWR VPWR SLICE[0].RAM8x32.Di[8]
+ sky130_fd_sc_hd__clkbuf_16
XDIBUF[9] Di[9] VGND VGND VPWR VPWR SLICE[0].RAM8x32.Di[9]
+ sky130_fd_sc_hd__clkbuf_16
XDo_FF[0] CLK SLICE[0].RAM8x32.Do[0] VGND VGND VPWR VPWR Do[0]
+ sky130_fd_sc_hd__dfxtp_1
XDo_FF[10] CLK SLICE[0].RAM8x32.Do[10] VGND VGND VPWR VPWR Do[10]
+ sky130_fd_sc_hd__dfxtp_1
XDo_FF[11] CLK SLICE[0].RAM8x32.Do[11] VGND VGND VPWR VPWR Do[11]
+ sky130_fd_sc_hd__dfxtp_1
XDo_FF[12] CLK SLICE[0].RAM8x32.Do[12] VGND VGND VPWR VPWR Do[12]
+ sky130_fd_sc_hd__dfxtp_1
XDo_FF[13] CLK SLICE[0].RAM8x32.Do[13] VGND VGND VPWR VPWR Do[13]
+ sky130_fd_sc_hd__dfxtp_1
XDo_FF[14] CLK SLICE[0].RAM8x32.Do[14] VGND VGND VPWR VPWR Do[14]
+ sky130_fd_sc_hd__dfxtp_1
XDo_FF[15] CLK SLICE[0].RAM8x32.Do[15] VGND VGND VPWR VPWR Do[15]
+ sky130_fd_sc_hd__dfxtp_1
XDo_FF[16] CLK SLICE[0].RAM8x32.Do[16] VGND VGND VPWR VPWR Do[16]
+ sky130_fd_sc_hd__dfxtp_1
XDo_FF[17] CLK SLICE[0].RAM8x32.Do[17] VGND VGND VPWR VPWR Do[17]
+ sky130_fd_sc_hd__dfxtp_1
XDo_FF[18] CLK SLICE[0].RAM8x32.Do[18] VGND VGND VPWR VPWR Do[18]
+ sky130_fd_sc_hd__dfxtp_1
XDo_FF[19] CLK SLICE[0].RAM8x32.Do[19] VGND VGND VPWR VPWR Do[19]
+ sky130_fd_sc_hd__dfxtp_1
XDo_FF[1] CLK SLICE[0].RAM8x32.Do[1] VGND VGND VPWR VPWR Do[1]
+ sky130_fd_sc_hd__dfxtp_1
XDo_FF[20] CLK SLICE[0].RAM8x32.Do[20] VGND VGND VPWR VPWR Do[20]
+ sky130_fd_sc_hd__dfxtp_1
XDo_FF[21] CLK SLICE[0].RAM8x32.Do[21] VGND VGND VPWR VPWR Do[21]
+ sky130_fd_sc_hd__dfxtp_1
XDo_FF[22] CLK SLICE[0].RAM8x32.Do[22] VGND VGND VPWR VPWR Do[22]
+ sky130_fd_sc_hd__dfxtp_1
XDo_FF[23] CLK SLICE[0].RAM8x32.Do[23] VGND VGND VPWR VPWR Do[23]
+ sky130_fd_sc_hd__dfxtp_1
XDo_FF[24] CLK SLICE[0].RAM8x32.Do[24] VGND VGND VPWR VPWR Do[24]
+ sky130_fd_sc_hd__dfxtp_1
XDo_FF[25] CLK SLICE[0].RAM8x32.Do[25] VGND VGND VPWR VPWR Do[25]
+ sky130_fd_sc_hd__dfxtp_1
XDo_FF[26] CLK SLICE[0].RAM8x32.Do[26] VGND VGND VPWR VPWR Do[26]
+ sky130_fd_sc_hd__dfxtp_1
XDo_FF[27] CLK SLICE[0].RAM8x32.Do[27] VGND VGND VPWR VPWR Do[27]
+ sky130_fd_sc_hd__dfxtp_1
XDo_FF[28] CLK SLICE[0].RAM8x32.Do[28] VGND VGND VPWR VPWR Do[28]
+ sky130_fd_sc_hd__dfxtp_1
XDo_FF[29] CLK SLICE[0].RAM8x32.Do[29] VGND VGND VPWR VPWR Do[29]
+ sky130_fd_sc_hd__dfxtp_1
XDo_FF[2] CLK SLICE[0].RAM8x32.Do[2] VGND VGND VPWR VPWR Do[2]
+ sky130_fd_sc_hd__dfxtp_1
XDo_FF[30] CLK SLICE[0].RAM8x32.Do[30] VGND VGND VPWR VPWR Do[30]
+ sky130_fd_sc_hd__dfxtp_1
XDo_FF[31] CLK SLICE[0].RAM8x32.Do[31] VGND VGND VPWR VPWR Do[31]
+ sky130_fd_sc_hd__dfxtp_1
XDo_FF[3] CLK SLICE[0].RAM8x32.Do[3] VGND VGND VPWR VPWR Do[3]
+ sky130_fd_sc_hd__dfxtp_1
XDo_FF[4] CLK SLICE[0].RAM8x32.Do[4] VGND VGND VPWR VPWR Do[4]
+ sky130_fd_sc_hd__dfxtp_1
XDo_FF[5] CLK SLICE[0].RAM8x32.Do[5] VGND VGND VPWR VPWR Do[5]
+ sky130_fd_sc_hd__dfxtp_1
XDo_FF[6] CLK SLICE[0].RAM8x32.Do[6] VGND VGND VPWR VPWR Do[6]
+ sky130_fd_sc_hd__dfxtp_1
XDo_FF[7] CLK SLICE[0].RAM8x32.Do[7] VGND VGND VPWR VPWR Do[7]
+ sky130_fd_sc_hd__dfxtp_1
XDo_FF[8] CLK SLICE[0].RAM8x32.Do[8] VGND VGND VPWR VPWR Do[8]
+ sky130_fd_sc_hd__dfxtp_1
XDo_FF[9] CLK SLICE[0].RAM8x32.Do[9] VGND VGND VPWR VPWR Do[9]
+ sky130_fd_sc_hd__dfxtp_1
XENBUF EN VGND VGND VPWR VPWR DEC.EN sky130_fd_sc_hd__clkbuf_2
XFBUFENBUF[0] EN VGND VGND VPWR VPWR float_buf_en[0] sky130_fd_sc_hd__clkbuf_2
XFBUFENBUF[1] EN VGND VGND VPWR VPWR float_buf_en[1] sky130_fd_sc_hd__clkbuf_2
XFBUFENBUF[2] EN VGND VGND VPWR VPWR float_buf_en[2] sky130_fd_sc_hd__clkbuf_2
XFBUFENBUF[3] EN VGND VGND VPWR VPWR float_buf_en[3] sky130_fd_sc_hd__clkbuf_2
XFLOATBUF_B0[0] lo[0] float_buf_en[0] VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.Do[0] sky130_fd_sc_hd__ebufn_2
XFLOATBUF_B0[1] lo[0] float_buf_en[0] VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.Do[1] sky130_fd_sc_hd__ebufn_2
XFLOATBUF_B0[2] lo[0] float_buf_en[0] VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.Do[2] sky130_fd_sc_hd__ebufn_2
XFLOATBUF_B0[3] lo[0] float_buf_en[0] VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.Do[3] sky130_fd_sc_hd__ebufn_2
XFLOATBUF_B0[4] lo[0] float_buf_en[0] VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.Do[4] sky130_fd_sc_hd__ebufn_2
XFLOATBUF_B0[5] lo[0] float_buf_en[0] VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.Do[5] sky130_fd_sc_hd__ebufn_2
XFLOATBUF_B0[6] lo[0] float_buf_en[0] VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.Do[6] sky130_fd_sc_hd__ebufn_2
XFLOATBUF_B0[7] lo[0] float_buf_en[0] VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.Do[7] sky130_fd_sc_hd__ebufn_2
XFLOATBUF_B1[10] lo[1] float_buf_en[1] VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.Do[10] sky130_fd_sc_hd__ebufn_2
XFLOATBUF_B1[11] lo[1] float_buf_en[1] VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.Do[11] sky130_fd_sc_hd__ebufn_2
XFLOATBUF_B1[12] lo[1] float_buf_en[1] VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.Do[12] sky130_fd_sc_hd__ebufn_2
XFLOATBUF_B1[13] lo[1] float_buf_en[1] VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.Do[13] sky130_fd_sc_hd__ebufn_2
XFLOATBUF_B1[14] lo[1] float_buf_en[1] VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.Do[14] sky130_fd_sc_hd__ebufn_2
XFLOATBUF_B1[15] lo[1] float_buf_en[1] VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.Do[15] sky130_fd_sc_hd__ebufn_2
XFLOATBUF_B1[8] lo[1] float_buf_en[1] VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.Do[8] sky130_fd_sc_hd__ebufn_2
XFLOATBUF_B1[9] lo[1] float_buf_en[1] VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.Do[9] sky130_fd_sc_hd__ebufn_2
XFLOATBUF_B2[16] lo[2] float_buf_en[2] VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.Do[16] sky130_fd_sc_hd__ebufn_2
XFLOATBUF_B2[17] lo[2] float_buf_en[2] VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.Do[17] sky130_fd_sc_hd__ebufn_2
XFLOATBUF_B2[18] lo[2] float_buf_en[2] VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.Do[18] sky130_fd_sc_hd__ebufn_2
XFLOATBUF_B2[19] lo[2] float_buf_en[2] VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.Do[19] sky130_fd_sc_hd__ebufn_2
XFLOATBUF_B2[20] lo[2] float_buf_en[2] VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.Do[20] sky130_fd_sc_hd__ebufn_2
XFLOATBUF_B2[21] lo[2] float_buf_en[2] VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.Do[21] sky130_fd_sc_hd__ebufn_2
XFLOATBUF_B2[22] lo[2] float_buf_en[2] VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.Do[22] sky130_fd_sc_hd__ebufn_2
XFLOATBUF_B2[23] lo[2] float_buf_en[2] VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.Do[23] sky130_fd_sc_hd__ebufn_2
XFLOATBUF_B3[24] lo[3] float_buf_en[3] VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.Do[24] sky130_fd_sc_hd__ebufn_2
XFLOATBUF_B3[25] lo[3] float_buf_en[3] VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.Do[25] sky130_fd_sc_hd__ebufn_2
XFLOATBUF_B3[26] lo[3] float_buf_en[3] VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.Do[26] sky130_fd_sc_hd__ebufn_2
XFLOATBUF_B3[27] lo[3] float_buf_en[3] VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.Do[27] sky130_fd_sc_hd__ebufn_2
XFLOATBUF_B3[28] lo[3] float_buf_en[3] VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.Do[28] sky130_fd_sc_hd__ebufn_2
XFLOATBUF_B3[29] lo[3] float_buf_en[3] VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.Do[29] sky130_fd_sc_hd__ebufn_2
XFLOATBUF_B3[30] lo[3] float_buf_en[3] VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.Do[30] sky130_fd_sc_hd__ebufn_2
XFLOATBUF_B3[31] lo[3] float_buf_en[3] VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.Do[31] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.CLKBUF SLICE[0].RAM8x32.CLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.CLK_buf sky130_fd_sc_hd__clkbuf_2
XSLICE[0].RAM8x32.DEC.ABUF[0] SLICE[0].RAM8x32.A[0] VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.DEC.A_buf[0] sky130_fd_sc_hd__clkbuf_2
XSLICE[0].RAM8x32.DEC.ABUF[1] SLICE[0].RAM8x32.A[1] VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.DEC.A_buf[1] sky130_fd_sc_hd__clkbuf_2
XSLICE[0].RAM8x32.DEC.ABUF[2] SLICE[0].RAM8x32.A[2] VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.DEC.A_buf[2] sky130_fd_sc_hd__clkbuf_2
XSLICE[0].RAM8x32.DEC.AND0 SLICE[0].RAM8x32.DEC.A_buf[0]
+ SLICE[0].RAM8x32.DEC.A_buf[1] SLICE[0].RAM8x32.DEC.A_buf[2]
+ SLICE[0].RAM8x32.DEC.EN_buf VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[0].W.SEL sky130_fd_sc_hd__nor4b_2
XSLICE[0].RAM8x32.DEC.AND1 SLICE[0].RAM8x32.DEC.A_buf[2]
+ SLICE[0].RAM8x32.DEC.A_buf[1] SLICE[0].RAM8x32.DEC.A_buf[0]
+ SLICE[0].RAM8x32.DEC.EN_buf VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[1].W.SEL sky130_fd_sc_hd__and4bb_2
XSLICE[0].RAM8x32.DEC.AND2 SLICE[0].RAM8x32.DEC.A_buf[2]
+ SLICE[0].RAM8x32.DEC.A_buf[0] SLICE[0].RAM8x32.DEC.A_buf[1]
+ SLICE[0].RAM8x32.DEC.EN_buf VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[2].W.SEL sky130_fd_sc_hd__and4bb_2
XSLICE[0].RAM8x32.DEC.AND3 SLICE[0].RAM8x32.DEC.A_buf[2]
+ SLICE[0].RAM8x32.DEC.A_buf[1] SLICE[0].RAM8x32.DEC.A_buf[0]
+ SLICE[0].RAM8x32.DEC.EN_buf VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[3].W.SEL sky130_fd_sc_hd__and4b_2
XSLICE[0].RAM8x32.DEC.AND4 SLICE[0].RAM8x32.DEC.A_buf[0]
+ SLICE[0].RAM8x32.DEC.A_buf[1] SLICE[0].RAM8x32.DEC.A_buf[2]
+ SLICE[0].RAM8x32.DEC.EN_buf VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[4].W.SEL sky130_fd_sc_hd__and4bb_2
XSLICE[0].RAM8x32.DEC.AND5 SLICE[0].RAM8x32.DEC.A_buf[1]
+ SLICE[0].RAM8x32.DEC.A_buf[0] SLICE[0].RAM8x32.DEC.A_buf[2]
+ SLICE[0].RAM8x32.DEC.EN_buf VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[5].W.SEL sky130_fd_sc_hd__and4b_2
XSLICE[0].RAM8x32.DEC.AND6 SLICE[0].RAM8x32.DEC.A_buf[0]
+ SLICE[0].RAM8x32.DEC.A_buf[1] SLICE[0].RAM8x32.DEC.A_buf[2]
+ SLICE[0].RAM8x32.DEC.EN_buf VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[6].W.SEL sky130_fd_sc_hd__and4b_2
XSLICE[0].RAM8x32.DEC.AND7 SLICE[0].RAM8x32.DEC.A_buf[0]
+ SLICE[0].RAM8x32.DEC.A_buf[1] SLICE[0].RAM8x32.DEC.A_buf[2]
+ SLICE[0].RAM8x32.DEC.EN_buf VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[7].W.SEL sky130_fd_sc_hd__and4_2
XSLICE[0].RAM8x32.DEC.ENBUF SLICE[0].RAM8x32.DEC.EN VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.DEC.EN_buf sky130_fd_sc_hd__clkbuf_2
XSLICE[0].RAM8x32.WEBUF[0] SLICE[0].RAM8x32.WE[0] VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[0].W.B0.WE sky130_fd_sc_hd__clkbuf_2
XSLICE[0].RAM8x32.WEBUF[1] SLICE[0].RAM8x32.WE[1] VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[0].W.B1.WE sky130_fd_sc_hd__clkbuf_2
XSLICE[0].RAM8x32.WEBUF[2] SLICE[0].RAM8x32.WE[2] VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[0].W.B2.WE sky130_fd_sc_hd__clkbuf_2
XSLICE[0].RAM8x32.WEBUF[3] SLICE[0].RAM8x32.WE[3] VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[0].W.B3.WE sky130_fd_sc_hd__clkbuf_2
XSLICE[0].RAM8x32.WORD[0].W.B0.BIT[0].LATCH SLICE[0].RAM8x32.Di[0]
+ SLICE[0].RAM8x32.WORD[0].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[0].W.B0.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[0].W.B0.BIT[0].OBUF
+ SLICE[0].RAM8x32.WORD[0].W.B0.q_wire[0] SLICE[0].RAM8x32.WORD[0].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[0] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[0].W.B0.BIT[1].LATCH SLICE[0].RAM8x32.Di[1]
+ SLICE[0].RAM8x32.WORD[0].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[0].W.B0.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[0].W.B0.BIT[1].OBUF
+ SLICE[0].RAM8x32.WORD[0].W.B0.q_wire[1] SLICE[0].RAM8x32.WORD[0].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[1] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[0].W.B0.BIT[2].LATCH SLICE[0].RAM8x32.Di[2]
+ SLICE[0].RAM8x32.WORD[0].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[0].W.B0.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[0].W.B0.BIT[2].OBUF
+ SLICE[0].RAM8x32.WORD[0].W.B0.q_wire[2] SLICE[0].RAM8x32.WORD[0].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[2] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[0].W.B0.BIT[3].LATCH SLICE[0].RAM8x32.Di[3]
+ SLICE[0].RAM8x32.WORD[0].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[0].W.B0.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[0].W.B0.BIT[3].OBUF
+ SLICE[0].RAM8x32.WORD[0].W.B0.q_wire[3] SLICE[0].RAM8x32.WORD[0].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[3] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[0].W.B0.BIT[4].LATCH SLICE[0].RAM8x32.Di[4]
+ SLICE[0].RAM8x32.WORD[0].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[0].W.B0.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[0].W.B0.BIT[4].OBUF
+ SLICE[0].RAM8x32.WORD[0].W.B0.q_wire[4] SLICE[0].RAM8x32.WORD[0].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[4] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[0].W.B0.BIT[5].LATCH SLICE[0].RAM8x32.Di[5]
+ SLICE[0].RAM8x32.WORD[0].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[0].W.B0.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[0].W.B0.BIT[5].OBUF
+ SLICE[0].RAM8x32.WORD[0].W.B0.q_wire[5] SLICE[0].RAM8x32.WORD[0].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[5] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[0].W.B0.BIT[6].LATCH SLICE[0].RAM8x32.Di[6]
+ SLICE[0].RAM8x32.WORD[0].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[0].W.B0.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[0].W.B0.BIT[6].OBUF
+ SLICE[0].RAM8x32.WORD[0].W.B0.q_wire[6] SLICE[0].RAM8x32.WORD[0].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[6] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[0].W.B0.BIT[7].LATCH SLICE[0].RAM8x32.Di[7]
+ SLICE[0].RAM8x32.WORD[0].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[0].W.B0.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[0].W.B0.BIT[7].OBUF
+ SLICE[0].RAM8x32.WORD[0].W.B0.q_wire[7] SLICE[0].RAM8x32.WORD[0].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[7] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[0].W.B0.CG SLICE[0].RAM8x32.WORD[0].W.B0.CLK_B
+ SLICE[0].RAM8x32.WORD[0].W.B0.we_wire VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[0].W.B0.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[0].RAM8x32.WORD[0].W.B0.CGAND SLICE[0].RAM8x32.WORD[0].W.B0.SEL
+ SLICE[0].RAM8x32.WORD[0].W.B0.WE VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[0].W.B0.we_wire sky130_fd_sc_hd__and2_1
XSLICE[0].RAM8x32.WORD[0].W.B0.CLKINV SLICE[0].RAM8x32.WORD[0].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[0].W.B0.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[0].W.B0.SELINV SLICE[0].RAM8x32.WORD[0].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[0].W.B0.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[0].W.B1.BIT[0].LATCH SLICE[0].RAM8x32.Di[8]
+ SLICE[0].RAM8x32.WORD[0].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[0].W.B1.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[0].W.B1.BIT[0].OBUF
+ SLICE[0].RAM8x32.WORD[0].W.B1.q_wire[0] SLICE[0].RAM8x32.WORD[0].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[8] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[0].W.B1.BIT[1].LATCH SLICE[0].RAM8x32.Di[9]
+ SLICE[0].RAM8x32.WORD[0].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[0].W.B1.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[0].W.B1.BIT[1].OBUF
+ SLICE[0].RAM8x32.WORD[0].W.B1.q_wire[1] SLICE[0].RAM8x32.WORD[0].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[9] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[0].W.B1.BIT[2].LATCH SLICE[0].RAM8x32.Di[10]
+ SLICE[0].RAM8x32.WORD[0].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[0].W.B1.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[0].W.B1.BIT[2].OBUF
+ SLICE[0].RAM8x32.WORD[0].W.B1.q_wire[2] SLICE[0].RAM8x32.WORD[0].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[10] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[0].W.B1.BIT[3].LATCH SLICE[0].RAM8x32.Di[11]
+ SLICE[0].RAM8x32.WORD[0].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[0].W.B1.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[0].W.B1.BIT[3].OBUF
+ SLICE[0].RAM8x32.WORD[0].W.B1.q_wire[3] SLICE[0].RAM8x32.WORD[0].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[11] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[0].W.B1.BIT[4].LATCH SLICE[0].RAM8x32.Di[12]
+ SLICE[0].RAM8x32.WORD[0].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[0].W.B1.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[0].W.B1.BIT[4].OBUF
+ SLICE[0].RAM8x32.WORD[0].W.B1.q_wire[4] SLICE[0].RAM8x32.WORD[0].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[12] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[0].W.B1.BIT[5].LATCH SLICE[0].RAM8x32.Di[13]
+ SLICE[0].RAM8x32.WORD[0].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[0].W.B1.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[0].W.B1.BIT[5].OBUF
+ SLICE[0].RAM8x32.WORD[0].W.B1.q_wire[5] SLICE[0].RAM8x32.WORD[0].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[13] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[0].W.B1.BIT[6].LATCH SLICE[0].RAM8x32.Di[14]
+ SLICE[0].RAM8x32.WORD[0].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[0].W.B1.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[0].W.B1.BIT[6].OBUF
+ SLICE[0].RAM8x32.WORD[0].W.B1.q_wire[6] SLICE[0].RAM8x32.WORD[0].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[14] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[0].W.B1.BIT[7].LATCH SLICE[0].RAM8x32.Di[15]
+ SLICE[0].RAM8x32.WORD[0].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[0].W.B1.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[0].W.B1.BIT[7].OBUF
+ SLICE[0].RAM8x32.WORD[0].W.B1.q_wire[7] SLICE[0].RAM8x32.WORD[0].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[15] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[0].W.B1.CG SLICE[0].RAM8x32.WORD[0].W.B1.CLK_B
+ SLICE[0].RAM8x32.WORD[0].W.B1.we_wire VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[0].W.B1.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[0].RAM8x32.WORD[0].W.B1.CGAND SLICE[0].RAM8x32.WORD[0].W.B0.SEL
+ SLICE[0].RAM8x32.WORD[0].W.B1.WE VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[0].W.B1.we_wire sky130_fd_sc_hd__and2_1
XSLICE[0].RAM8x32.WORD[0].W.B1.CLKINV SLICE[0].RAM8x32.WORD[0].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[0].W.B1.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[0].W.B1.SELINV SLICE[0].RAM8x32.WORD[0].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[0].W.B1.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[0].W.B2.BIT[0].LATCH SLICE[0].RAM8x32.Di[16]
+ SLICE[0].RAM8x32.WORD[0].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[0].W.B2.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[0].W.B2.BIT[0].OBUF
+ SLICE[0].RAM8x32.WORD[0].W.B2.q_wire[0] SLICE[0].RAM8x32.WORD[0].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[16] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[0].W.B2.BIT[1].LATCH SLICE[0].RAM8x32.Di[17]
+ SLICE[0].RAM8x32.WORD[0].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[0].W.B2.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[0].W.B2.BIT[1].OBUF
+ SLICE[0].RAM8x32.WORD[0].W.B2.q_wire[1] SLICE[0].RAM8x32.WORD[0].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[17] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[0].W.B2.BIT[2].LATCH SLICE[0].RAM8x32.Di[18]
+ SLICE[0].RAM8x32.WORD[0].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[0].W.B2.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[0].W.B2.BIT[2].OBUF
+ SLICE[0].RAM8x32.WORD[0].W.B2.q_wire[2] SLICE[0].RAM8x32.WORD[0].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[18] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[0].W.B2.BIT[3].LATCH SLICE[0].RAM8x32.Di[19]
+ SLICE[0].RAM8x32.WORD[0].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[0].W.B2.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[0].W.B2.BIT[3].OBUF
+ SLICE[0].RAM8x32.WORD[0].W.B2.q_wire[3] SLICE[0].RAM8x32.WORD[0].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[19] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[0].W.B2.BIT[4].LATCH SLICE[0].RAM8x32.Di[20]
+ SLICE[0].RAM8x32.WORD[0].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[0].W.B2.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[0].W.B2.BIT[4].OBUF
+ SLICE[0].RAM8x32.WORD[0].W.B2.q_wire[4] SLICE[0].RAM8x32.WORD[0].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[20] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[0].W.B2.BIT[5].LATCH SLICE[0].RAM8x32.Di[21]
+ SLICE[0].RAM8x32.WORD[0].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[0].W.B2.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[0].W.B2.BIT[5].OBUF
+ SLICE[0].RAM8x32.WORD[0].W.B2.q_wire[5] SLICE[0].RAM8x32.WORD[0].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[21] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[0].W.B2.BIT[6].LATCH SLICE[0].RAM8x32.Di[22]
+ SLICE[0].RAM8x32.WORD[0].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[0].W.B2.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[0].W.B2.BIT[6].OBUF
+ SLICE[0].RAM8x32.WORD[0].W.B2.q_wire[6] SLICE[0].RAM8x32.WORD[0].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[22] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[0].W.B2.BIT[7].LATCH SLICE[0].RAM8x32.Di[23]
+ SLICE[0].RAM8x32.WORD[0].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[0].W.B2.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[0].W.B2.BIT[7].OBUF
+ SLICE[0].RAM8x32.WORD[0].W.B2.q_wire[7] SLICE[0].RAM8x32.WORD[0].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[23] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[0].W.B2.CG SLICE[0].RAM8x32.WORD[0].W.B2.CLK_B
+ SLICE[0].RAM8x32.WORD[0].W.B2.we_wire VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[0].W.B2.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[0].RAM8x32.WORD[0].W.B2.CGAND SLICE[0].RAM8x32.WORD[0].W.B0.SEL
+ SLICE[0].RAM8x32.WORD[0].W.B2.WE VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[0].W.B2.we_wire sky130_fd_sc_hd__and2_1
XSLICE[0].RAM8x32.WORD[0].W.B2.CLKINV SLICE[0].RAM8x32.WORD[0].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[0].W.B2.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[0].W.B2.SELINV SLICE[0].RAM8x32.WORD[0].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[0].W.B2.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[0].W.B3.BIT[0].LATCH SLICE[0].RAM8x32.Di[24]
+ SLICE[0].RAM8x32.WORD[0].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[0].W.B3.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[0].W.B3.BIT[0].OBUF
+ SLICE[0].RAM8x32.WORD[0].W.B3.q_wire[0] SLICE[0].RAM8x32.WORD[0].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[24] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[0].W.B3.BIT[1].LATCH SLICE[0].RAM8x32.Di[25]
+ SLICE[0].RAM8x32.WORD[0].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[0].W.B3.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[0].W.B3.BIT[1].OBUF
+ SLICE[0].RAM8x32.WORD[0].W.B3.q_wire[1] SLICE[0].RAM8x32.WORD[0].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[25] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[0].W.B3.BIT[2].LATCH SLICE[0].RAM8x32.Di[26]
+ SLICE[0].RAM8x32.WORD[0].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[0].W.B3.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[0].W.B3.BIT[2].OBUF
+ SLICE[0].RAM8x32.WORD[0].W.B3.q_wire[2] SLICE[0].RAM8x32.WORD[0].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[26] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[0].W.B3.BIT[3].LATCH SLICE[0].RAM8x32.Di[27]
+ SLICE[0].RAM8x32.WORD[0].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[0].W.B3.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[0].W.B3.BIT[3].OBUF
+ SLICE[0].RAM8x32.WORD[0].W.B3.q_wire[3] SLICE[0].RAM8x32.WORD[0].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[27] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[0].W.B3.BIT[4].LATCH SLICE[0].RAM8x32.Di[28]
+ SLICE[0].RAM8x32.WORD[0].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[0].W.B3.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[0].W.B3.BIT[4].OBUF
+ SLICE[0].RAM8x32.WORD[0].W.B3.q_wire[4] SLICE[0].RAM8x32.WORD[0].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[28] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[0].W.B3.BIT[5].LATCH SLICE[0].RAM8x32.Di[29]
+ SLICE[0].RAM8x32.WORD[0].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[0].W.B3.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[0].W.B3.BIT[5].OBUF
+ SLICE[0].RAM8x32.WORD[0].W.B3.q_wire[5] SLICE[0].RAM8x32.WORD[0].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[29] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[0].W.B3.BIT[6].LATCH SLICE[0].RAM8x32.Di[30]
+ SLICE[0].RAM8x32.WORD[0].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[0].W.B3.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[0].W.B3.BIT[6].OBUF
+ SLICE[0].RAM8x32.WORD[0].W.B3.q_wire[6] SLICE[0].RAM8x32.WORD[0].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[30] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[0].W.B3.BIT[7].LATCH SLICE[0].RAM8x32.Di[31]
+ SLICE[0].RAM8x32.WORD[0].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[0].W.B3.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[0].W.B3.BIT[7].OBUF
+ SLICE[0].RAM8x32.WORD[0].W.B3.q_wire[7] SLICE[0].RAM8x32.WORD[0].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[31] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[0].W.B3.CG SLICE[0].RAM8x32.WORD[0].W.B3.CLK_B
+ SLICE[0].RAM8x32.WORD[0].W.B3.we_wire VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[0].W.B3.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[0].RAM8x32.WORD[0].W.B3.CGAND SLICE[0].RAM8x32.WORD[0].W.B0.SEL
+ SLICE[0].RAM8x32.WORD[0].W.B3.WE VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[0].W.B3.we_wire sky130_fd_sc_hd__and2_1
XSLICE[0].RAM8x32.WORD[0].W.B3.CLKINV SLICE[0].RAM8x32.WORD[0].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[0].W.B3.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[0].W.B3.SELINV SLICE[0].RAM8x32.WORD[0].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[0].W.B3.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[0].W.CLKBUF SLICE[0].RAM8x32.CLK_buf VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[0].W.B0.CLK sky130_fd_sc_hd__clkbuf_1
XSLICE[0].RAM8x32.WORD[0].W.SELBUF SLICE[0].RAM8x32.WORD[0].W.SEL VGND VGND
+ VPWR VPWR SLICE[0].RAM8x32.WORD[0].W.B0.SEL sky130_fd_sc_hd__clkbuf_2
XSLICE[0].RAM8x32.WORD[1].W.B0.BIT[0].LATCH SLICE[0].RAM8x32.Di[0]
+ SLICE[0].RAM8x32.WORD[1].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[1].W.B0.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[1].W.B0.BIT[0].OBUF
+ SLICE[0].RAM8x32.WORD[1].W.B0.q_wire[0] SLICE[0].RAM8x32.WORD[1].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[0] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[1].W.B0.BIT[1].LATCH SLICE[0].RAM8x32.Di[1]
+ SLICE[0].RAM8x32.WORD[1].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[1].W.B0.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[1].W.B0.BIT[1].OBUF
+ SLICE[0].RAM8x32.WORD[1].W.B0.q_wire[1] SLICE[0].RAM8x32.WORD[1].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[1] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[1].W.B0.BIT[2].LATCH SLICE[0].RAM8x32.Di[2]
+ SLICE[0].RAM8x32.WORD[1].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[1].W.B0.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[1].W.B0.BIT[2].OBUF
+ SLICE[0].RAM8x32.WORD[1].W.B0.q_wire[2] SLICE[0].RAM8x32.WORD[1].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[2] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[1].W.B0.BIT[3].LATCH SLICE[0].RAM8x32.Di[3]
+ SLICE[0].RAM8x32.WORD[1].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[1].W.B0.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[1].W.B0.BIT[3].OBUF
+ SLICE[0].RAM8x32.WORD[1].W.B0.q_wire[3] SLICE[0].RAM8x32.WORD[1].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[3] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[1].W.B0.BIT[4].LATCH SLICE[0].RAM8x32.Di[4]
+ SLICE[0].RAM8x32.WORD[1].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[1].W.B0.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[1].W.B0.BIT[4].OBUF
+ SLICE[0].RAM8x32.WORD[1].W.B0.q_wire[4] SLICE[0].RAM8x32.WORD[1].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[4] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[1].W.B0.BIT[5].LATCH SLICE[0].RAM8x32.Di[5]
+ SLICE[0].RAM8x32.WORD[1].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[1].W.B0.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[1].W.B0.BIT[5].OBUF
+ SLICE[0].RAM8x32.WORD[1].W.B0.q_wire[5] SLICE[0].RAM8x32.WORD[1].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[5] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[1].W.B0.BIT[6].LATCH SLICE[0].RAM8x32.Di[6]
+ SLICE[0].RAM8x32.WORD[1].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[1].W.B0.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[1].W.B0.BIT[6].OBUF
+ SLICE[0].RAM8x32.WORD[1].W.B0.q_wire[6] SLICE[0].RAM8x32.WORD[1].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[6] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[1].W.B0.BIT[7].LATCH SLICE[0].RAM8x32.Di[7]
+ SLICE[0].RAM8x32.WORD[1].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[1].W.B0.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[1].W.B0.BIT[7].OBUF
+ SLICE[0].RAM8x32.WORD[1].W.B0.q_wire[7] SLICE[0].RAM8x32.WORD[1].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[7] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[1].W.B0.CG SLICE[0].RAM8x32.WORD[1].W.B0.CLK_B
+ SLICE[0].RAM8x32.WORD[1].W.B0.we_wire VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[1].W.B0.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[0].RAM8x32.WORD[1].W.B0.CGAND SLICE[0].RAM8x32.WORD[1].W.B0.SEL
+ SLICE[0].RAM8x32.WORD[0].W.B0.WE VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[1].W.B0.we_wire sky130_fd_sc_hd__and2_1
XSLICE[0].RAM8x32.WORD[1].W.B0.CLKINV SLICE[0].RAM8x32.WORD[1].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[1].W.B0.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[1].W.B0.SELINV SLICE[0].RAM8x32.WORD[1].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[1].W.B0.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[1].W.B1.BIT[0].LATCH SLICE[0].RAM8x32.Di[8]
+ SLICE[0].RAM8x32.WORD[1].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[1].W.B1.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[1].W.B1.BIT[0].OBUF
+ SLICE[0].RAM8x32.WORD[1].W.B1.q_wire[0] SLICE[0].RAM8x32.WORD[1].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[8] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[1].W.B1.BIT[1].LATCH SLICE[0].RAM8x32.Di[9]
+ SLICE[0].RAM8x32.WORD[1].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[1].W.B1.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[1].W.B1.BIT[1].OBUF
+ SLICE[0].RAM8x32.WORD[1].W.B1.q_wire[1] SLICE[0].RAM8x32.WORD[1].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[9] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[1].W.B1.BIT[2].LATCH SLICE[0].RAM8x32.Di[10]
+ SLICE[0].RAM8x32.WORD[1].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[1].W.B1.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[1].W.B1.BIT[2].OBUF
+ SLICE[0].RAM8x32.WORD[1].W.B1.q_wire[2] SLICE[0].RAM8x32.WORD[1].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[10] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[1].W.B1.BIT[3].LATCH SLICE[0].RAM8x32.Di[11]
+ SLICE[0].RAM8x32.WORD[1].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[1].W.B1.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[1].W.B1.BIT[3].OBUF
+ SLICE[0].RAM8x32.WORD[1].W.B1.q_wire[3] SLICE[0].RAM8x32.WORD[1].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[11] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[1].W.B1.BIT[4].LATCH SLICE[0].RAM8x32.Di[12]
+ SLICE[0].RAM8x32.WORD[1].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[1].W.B1.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[1].W.B1.BIT[4].OBUF
+ SLICE[0].RAM8x32.WORD[1].W.B1.q_wire[4] SLICE[0].RAM8x32.WORD[1].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[12] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[1].W.B1.BIT[5].LATCH SLICE[0].RAM8x32.Di[13]
+ SLICE[0].RAM8x32.WORD[1].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[1].W.B1.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[1].W.B1.BIT[5].OBUF
+ SLICE[0].RAM8x32.WORD[1].W.B1.q_wire[5] SLICE[0].RAM8x32.WORD[1].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[13] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[1].W.B1.BIT[6].LATCH SLICE[0].RAM8x32.Di[14]
+ SLICE[0].RAM8x32.WORD[1].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[1].W.B1.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[1].W.B1.BIT[6].OBUF
+ SLICE[0].RAM8x32.WORD[1].W.B1.q_wire[6] SLICE[0].RAM8x32.WORD[1].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[14] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[1].W.B1.BIT[7].LATCH SLICE[0].RAM8x32.Di[15]
+ SLICE[0].RAM8x32.WORD[1].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[1].W.B1.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[1].W.B1.BIT[7].OBUF
+ SLICE[0].RAM8x32.WORD[1].W.B1.q_wire[7] SLICE[0].RAM8x32.WORD[1].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[15] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[1].W.B1.CG SLICE[0].RAM8x32.WORD[1].W.B1.CLK_B
+ SLICE[0].RAM8x32.WORD[1].W.B1.we_wire VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[1].W.B1.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[0].RAM8x32.WORD[1].W.B1.CGAND SLICE[0].RAM8x32.WORD[1].W.B0.SEL
+ SLICE[0].RAM8x32.WORD[0].W.B1.WE VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[1].W.B1.we_wire sky130_fd_sc_hd__and2_1
XSLICE[0].RAM8x32.WORD[1].W.B1.CLKINV SLICE[0].RAM8x32.WORD[1].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[1].W.B1.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[1].W.B1.SELINV SLICE[0].RAM8x32.WORD[1].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[1].W.B1.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[1].W.B2.BIT[0].LATCH SLICE[0].RAM8x32.Di[16]
+ SLICE[0].RAM8x32.WORD[1].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[1].W.B2.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[1].W.B2.BIT[0].OBUF
+ SLICE[0].RAM8x32.WORD[1].W.B2.q_wire[0] SLICE[0].RAM8x32.WORD[1].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[16] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[1].W.B2.BIT[1].LATCH SLICE[0].RAM8x32.Di[17]
+ SLICE[0].RAM8x32.WORD[1].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[1].W.B2.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[1].W.B2.BIT[1].OBUF
+ SLICE[0].RAM8x32.WORD[1].W.B2.q_wire[1] SLICE[0].RAM8x32.WORD[1].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[17] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[1].W.B2.BIT[2].LATCH SLICE[0].RAM8x32.Di[18]
+ SLICE[0].RAM8x32.WORD[1].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[1].W.B2.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[1].W.B2.BIT[2].OBUF
+ SLICE[0].RAM8x32.WORD[1].W.B2.q_wire[2] SLICE[0].RAM8x32.WORD[1].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[18] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[1].W.B2.BIT[3].LATCH SLICE[0].RAM8x32.Di[19]
+ SLICE[0].RAM8x32.WORD[1].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[1].W.B2.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[1].W.B2.BIT[3].OBUF
+ SLICE[0].RAM8x32.WORD[1].W.B2.q_wire[3] SLICE[0].RAM8x32.WORD[1].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[19] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[1].W.B2.BIT[4].LATCH SLICE[0].RAM8x32.Di[20]
+ SLICE[0].RAM8x32.WORD[1].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[1].W.B2.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[1].W.B2.BIT[4].OBUF
+ SLICE[0].RAM8x32.WORD[1].W.B2.q_wire[4] SLICE[0].RAM8x32.WORD[1].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[20] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[1].W.B2.BIT[5].LATCH SLICE[0].RAM8x32.Di[21]
+ SLICE[0].RAM8x32.WORD[1].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[1].W.B2.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[1].W.B2.BIT[5].OBUF
+ SLICE[0].RAM8x32.WORD[1].W.B2.q_wire[5] SLICE[0].RAM8x32.WORD[1].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[21] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[1].W.B2.BIT[6].LATCH SLICE[0].RAM8x32.Di[22]
+ SLICE[0].RAM8x32.WORD[1].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[1].W.B2.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[1].W.B2.BIT[6].OBUF
+ SLICE[0].RAM8x32.WORD[1].W.B2.q_wire[6] SLICE[0].RAM8x32.WORD[1].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[22] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[1].W.B2.BIT[7].LATCH SLICE[0].RAM8x32.Di[23]
+ SLICE[0].RAM8x32.WORD[1].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[1].W.B2.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[1].W.B2.BIT[7].OBUF
+ SLICE[0].RAM8x32.WORD[1].W.B2.q_wire[7] SLICE[0].RAM8x32.WORD[1].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[23] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[1].W.B2.CG SLICE[0].RAM8x32.WORD[1].W.B2.CLK_B
+ SLICE[0].RAM8x32.WORD[1].W.B2.we_wire VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[1].W.B2.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[0].RAM8x32.WORD[1].W.B2.CGAND SLICE[0].RAM8x32.WORD[1].W.B0.SEL
+ SLICE[0].RAM8x32.WORD[0].W.B2.WE VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[1].W.B2.we_wire sky130_fd_sc_hd__and2_1
XSLICE[0].RAM8x32.WORD[1].W.B2.CLKINV SLICE[0].RAM8x32.WORD[1].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[1].W.B2.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[1].W.B2.SELINV SLICE[0].RAM8x32.WORD[1].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[1].W.B2.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[1].W.B3.BIT[0].LATCH SLICE[0].RAM8x32.Di[24]
+ SLICE[0].RAM8x32.WORD[1].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[1].W.B3.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[1].W.B3.BIT[0].OBUF
+ SLICE[0].RAM8x32.WORD[1].W.B3.q_wire[0] SLICE[0].RAM8x32.WORD[1].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[24] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[1].W.B3.BIT[1].LATCH SLICE[0].RAM8x32.Di[25]
+ SLICE[0].RAM8x32.WORD[1].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[1].W.B3.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[1].W.B3.BIT[1].OBUF
+ SLICE[0].RAM8x32.WORD[1].W.B3.q_wire[1] SLICE[0].RAM8x32.WORD[1].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[25] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[1].W.B3.BIT[2].LATCH SLICE[0].RAM8x32.Di[26]
+ SLICE[0].RAM8x32.WORD[1].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[1].W.B3.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[1].W.B3.BIT[2].OBUF
+ SLICE[0].RAM8x32.WORD[1].W.B3.q_wire[2] SLICE[0].RAM8x32.WORD[1].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[26] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[1].W.B3.BIT[3].LATCH SLICE[0].RAM8x32.Di[27]
+ SLICE[0].RAM8x32.WORD[1].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[1].W.B3.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[1].W.B3.BIT[3].OBUF
+ SLICE[0].RAM8x32.WORD[1].W.B3.q_wire[3] SLICE[0].RAM8x32.WORD[1].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[27] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[1].W.B3.BIT[4].LATCH SLICE[0].RAM8x32.Di[28]
+ SLICE[0].RAM8x32.WORD[1].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[1].W.B3.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[1].W.B3.BIT[4].OBUF
+ SLICE[0].RAM8x32.WORD[1].W.B3.q_wire[4] SLICE[0].RAM8x32.WORD[1].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[28] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[1].W.B3.BIT[5].LATCH SLICE[0].RAM8x32.Di[29]
+ SLICE[0].RAM8x32.WORD[1].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[1].W.B3.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[1].W.B3.BIT[5].OBUF
+ SLICE[0].RAM8x32.WORD[1].W.B3.q_wire[5] SLICE[0].RAM8x32.WORD[1].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[29] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[1].W.B3.BIT[6].LATCH SLICE[0].RAM8x32.Di[30]
+ SLICE[0].RAM8x32.WORD[1].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[1].W.B3.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[1].W.B3.BIT[6].OBUF
+ SLICE[0].RAM8x32.WORD[1].W.B3.q_wire[6] SLICE[0].RAM8x32.WORD[1].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[30] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[1].W.B3.BIT[7].LATCH SLICE[0].RAM8x32.Di[31]
+ SLICE[0].RAM8x32.WORD[1].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[1].W.B3.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[1].W.B3.BIT[7].OBUF
+ SLICE[0].RAM8x32.WORD[1].W.B3.q_wire[7] SLICE[0].RAM8x32.WORD[1].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[31] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[1].W.B3.CG SLICE[0].RAM8x32.WORD[1].W.B3.CLK_B
+ SLICE[0].RAM8x32.WORD[1].W.B3.we_wire VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[1].W.B3.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[0].RAM8x32.WORD[1].W.B3.CGAND SLICE[0].RAM8x32.WORD[1].W.B0.SEL
+ SLICE[0].RAM8x32.WORD[0].W.B3.WE VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[1].W.B3.we_wire sky130_fd_sc_hd__and2_1
XSLICE[0].RAM8x32.WORD[1].W.B3.CLKINV SLICE[0].RAM8x32.WORD[1].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[1].W.B3.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[1].W.B3.SELINV SLICE[0].RAM8x32.WORD[1].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[1].W.B3.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[1].W.CLKBUF SLICE[0].RAM8x32.CLK_buf VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[1].W.B0.CLK sky130_fd_sc_hd__clkbuf_1
XSLICE[0].RAM8x32.WORD[1].W.SELBUF SLICE[0].RAM8x32.WORD[1].W.SEL VGND VGND
+ VPWR VPWR SLICE[0].RAM8x32.WORD[1].W.B0.SEL sky130_fd_sc_hd__clkbuf_2
XSLICE[0].RAM8x32.WORD[2].W.B0.BIT[0].LATCH SLICE[0].RAM8x32.Di[0]
+ SLICE[0].RAM8x32.WORD[2].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[2].W.B0.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[2].W.B0.BIT[0].OBUF
+ SLICE[0].RAM8x32.WORD[2].W.B0.q_wire[0] SLICE[0].RAM8x32.WORD[2].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[0] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[2].W.B0.BIT[1].LATCH SLICE[0].RAM8x32.Di[1]
+ SLICE[0].RAM8x32.WORD[2].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[2].W.B0.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[2].W.B0.BIT[1].OBUF
+ SLICE[0].RAM8x32.WORD[2].W.B0.q_wire[1] SLICE[0].RAM8x32.WORD[2].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[1] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[2].W.B0.BIT[2].LATCH SLICE[0].RAM8x32.Di[2]
+ SLICE[0].RAM8x32.WORD[2].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[2].W.B0.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[2].W.B0.BIT[2].OBUF
+ SLICE[0].RAM8x32.WORD[2].W.B0.q_wire[2] SLICE[0].RAM8x32.WORD[2].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[2] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[2].W.B0.BIT[3].LATCH SLICE[0].RAM8x32.Di[3]
+ SLICE[0].RAM8x32.WORD[2].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[2].W.B0.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[2].W.B0.BIT[3].OBUF
+ SLICE[0].RAM8x32.WORD[2].W.B0.q_wire[3] SLICE[0].RAM8x32.WORD[2].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[3] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[2].W.B0.BIT[4].LATCH SLICE[0].RAM8x32.Di[4]
+ SLICE[0].RAM8x32.WORD[2].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[2].W.B0.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[2].W.B0.BIT[4].OBUF
+ SLICE[0].RAM8x32.WORD[2].W.B0.q_wire[4] SLICE[0].RAM8x32.WORD[2].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[4] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[2].W.B0.BIT[5].LATCH SLICE[0].RAM8x32.Di[5]
+ SLICE[0].RAM8x32.WORD[2].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[2].W.B0.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[2].W.B0.BIT[5].OBUF
+ SLICE[0].RAM8x32.WORD[2].W.B0.q_wire[5] SLICE[0].RAM8x32.WORD[2].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[5] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[2].W.B0.BIT[6].LATCH SLICE[0].RAM8x32.Di[6]
+ SLICE[0].RAM8x32.WORD[2].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[2].W.B0.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[2].W.B0.BIT[6].OBUF
+ SLICE[0].RAM8x32.WORD[2].W.B0.q_wire[6] SLICE[0].RAM8x32.WORD[2].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[6] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[2].W.B0.BIT[7].LATCH SLICE[0].RAM8x32.Di[7]
+ SLICE[0].RAM8x32.WORD[2].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[2].W.B0.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[2].W.B0.BIT[7].OBUF
+ SLICE[0].RAM8x32.WORD[2].W.B0.q_wire[7] SLICE[0].RAM8x32.WORD[2].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[7] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[2].W.B0.CG SLICE[0].RAM8x32.WORD[2].W.B0.CLK_B
+ SLICE[0].RAM8x32.WORD[2].W.B0.we_wire VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[2].W.B0.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[0].RAM8x32.WORD[2].W.B0.CGAND SLICE[0].RAM8x32.WORD[2].W.B0.SEL
+ SLICE[0].RAM8x32.WORD[0].W.B0.WE VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[2].W.B0.we_wire sky130_fd_sc_hd__and2_1
XSLICE[0].RAM8x32.WORD[2].W.B0.CLKINV SLICE[0].RAM8x32.WORD[2].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[2].W.B0.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[2].W.B0.SELINV SLICE[0].RAM8x32.WORD[2].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[2].W.B0.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[2].W.B1.BIT[0].LATCH SLICE[0].RAM8x32.Di[8]
+ SLICE[0].RAM8x32.WORD[2].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[2].W.B1.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[2].W.B1.BIT[0].OBUF
+ SLICE[0].RAM8x32.WORD[2].W.B1.q_wire[0] SLICE[0].RAM8x32.WORD[2].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[8] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[2].W.B1.BIT[1].LATCH SLICE[0].RAM8x32.Di[9]
+ SLICE[0].RAM8x32.WORD[2].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[2].W.B1.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[2].W.B1.BIT[1].OBUF
+ SLICE[0].RAM8x32.WORD[2].W.B1.q_wire[1] SLICE[0].RAM8x32.WORD[2].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[9] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[2].W.B1.BIT[2].LATCH SLICE[0].RAM8x32.Di[10]
+ SLICE[0].RAM8x32.WORD[2].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[2].W.B1.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[2].W.B1.BIT[2].OBUF
+ SLICE[0].RAM8x32.WORD[2].W.B1.q_wire[2] SLICE[0].RAM8x32.WORD[2].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[10] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[2].W.B1.BIT[3].LATCH SLICE[0].RAM8x32.Di[11]
+ SLICE[0].RAM8x32.WORD[2].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[2].W.B1.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[2].W.B1.BIT[3].OBUF
+ SLICE[0].RAM8x32.WORD[2].W.B1.q_wire[3] SLICE[0].RAM8x32.WORD[2].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[11] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[2].W.B1.BIT[4].LATCH SLICE[0].RAM8x32.Di[12]
+ SLICE[0].RAM8x32.WORD[2].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[2].W.B1.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[2].W.B1.BIT[4].OBUF
+ SLICE[0].RAM8x32.WORD[2].W.B1.q_wire[4] SLICE[0].RAM8x32.WORD[2].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[12] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[2].W.B1.BIT[5].LATCH SLICE[0].RAM8x32.Di[13]
+ SLICE[0].RAM8x32.WORD[2].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[2].W.B1.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[2].W.B1.BIT[5].OBUF
+ SLICE[0].RAM8x32.WORD[2].W.B1.q_wire[5] SLICE[0].RAM8x32.WORD[2].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[13] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[2].W.B1.BIT[6].LATCH SLICE[0].RAM8x32.Di[14]
+ SLICE[0].RAM8x32.WORD[2].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[2].W.B1.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[2].W.B1.BIT[6].OBUF
+ SLICE[0].RAM8x32.WORD[2].W.B1.q_wire[6] SLICE[0].RAM8x32.WORD[2].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[14] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[2].W.B1.BIT[7].LATCH SLICE[0].RAM8x32.Di[15]
+ SLICE[0].RAM8x32.WORD[2].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[2].W.B1.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[2].W.B1.BIT[7].OBUF
+ SLICE[0].RAM8x32.WORD[2].W.B1.q_wire[7] SLICE[0].RAM8x32.WORD[2].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[15] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[2].W.B1.CG SLICE[0].RAM8x32.WORD[2].W.B1.CLK_B
+ SLICE[0].RAM8x32.WORD[2].W.B1.we_wire VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[2].W.B1.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[0].RAM8x32.WORD[2].W.B1.CGAND SLICE[0].RAM8x32.WORD[2].W.B0.SEL
+ SLICE[0].RAM8x32.WORD[0].W.B1.WE VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[2].W.B1.we_wire sky130_fd_sc_hd__and2_1
XSLICE[0].RAM8x32.WORD[2].W.B1.CLKINV SLICE[0].RAM8x32.WORD[2].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[2].W.B1.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[2].W.B1.SELINV SLICE[0].RAM8x32.WORD[2].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[2].W.B1.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[2].W.B2.BIT[0].LATCH SLICE[0].RAM8x32.Di[16]
+ SLICE[0].RAM8x32.WORD[2].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[2].W.B2.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[2].W.B2.BIT[0].OBUF
+ SLICE[0].RAM8x32.WORD[2].W.B2.q_wire[0] SLICE[0].RAM8x32.WORD[2].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[16] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[2].W.B2.BIT[1].LATCH SLICE[0].RAM8x32.Di[17]
+ SLICE[0].RAM8x32.WORD[2].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[2].W.B2.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[2].W.B2.BIT[1].OBUF
+ SLICE[0].RAM8x32.WORD[2].W.B2.q_wire[1] SLICE[0].RAM8x32.WORD[2].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[17] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[2].W.B2.BIT[2].LATCH SLICE[0].RAM8x32.Di[18]
+ SLICE[0].RAM8x32.WORD[2].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[2].W.B2.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[2].W.B2.BIT[2].OBUF
+ SLICE[0].RAM8x32.WORD[2].W.B2.q_wire[2] SLICE[0].RAM8x32.WORD[2].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[18] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[2].W.B2.BIT[3].LATCH SLICE[0].RAM8x32.Di[19]
+ SLICE[0].RAM8x32.WORD[2].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[2].W.B2.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[2].W.B2.BIT[3].OBUF
+ SLICE[0].RAM8x32.WORD[2].W.B2.q_wire[3] SLICE[0].RAM8x32.WORD[2].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[19] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[2].W.B2.BIT[4].LATCH SLICE[0].RAM8x32.Di[20]
+ SLICE[0].RAM8x32.WORD[2].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[2].W.B2.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[2].W.B2.BIT[4].OBUF
+ SLICE[0].RAM8x32.WORD[2].W.B2.q_wire[4] SLICE[0].RAM8x32.WORD[2].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[20] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[2].W.B2.BIT[5].LATCH SLICE[0].RAM8x32.Di[21]
+ SLICE[0].RAM8x32.WORD[2].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[2].W.B2.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[2].W.B2.BIT[5].OBUF
+ SLICE[0].RAM8x32.WORD[2].W.B2.q_wire[5] SLICE[0].RAM8x32.WORD[2].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[21] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[2].W.B2.BIT[6].LATCH SLICE[0].RAM8x32.Di[22]
+ SLICE[0].RAM8x32.WORD[2].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[2].W.B2.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[2].W.B2.BIT[6].OBUF
+ SLICE[0].RAM8x32.WORD[2].W.B2.q_wire[6] SLICE[0].RAM8x32.WORD[2].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[22] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[2].W.B2.BIT[7].LATCH SLICE[0].RAM8x32.Di[23]
+ SLICE[0].RAM8x32.WORD[2].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[2].W.B2.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[2].W.B2.BIT[7].OBUF
+ SLICE[0].RAM8x32.WORD[2].W.B2.q_wire[7] SLICE[0].RAM8x32.WORD[2].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[23] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[2].W.B2.CG SLICE[0].RAM8x32.WORD[2].W.B2.CLK_B
+ SLICE[0].RAM8x32.WORD[2].W.B2.we_wire VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[2].W.B2.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[0].RAM8x32.WORD[2].W.B2.CGAND SLICE[0].RAM8x32.WORD[2].W.B0.SEL
+ SLICE[0].RAM8x32.WORD[0].W.B2.WE VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[2].W.B2.we_wire sky130_fd_sc_hd__and2_1
XSLICE[0].RAM8x32.WORD[2].W.B2.CLKINV SLICE[0].RAM8x32.WORD[2].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[2].W.B2.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[2].W.B2.SELINV SLICE[0].RAM8x32.WORD[2].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[2].W.B2.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[2].W.B3.BIT[0].LATCH SLICE[0].RAM8x32.Di[24]
+ SLICE[0].RAM8x32.WORD[2].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[2].W.B3.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[2].W.B3.BIT[0].OBUF
+ SLICE[0].RAM8x32.WORD[2].W.B3.q_wire[0] SLICE[0].RAM8x32.WORD[2].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[24] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[2].W.B3.BIT[1].LATCH SLICE[0].RAM8x32.Di[25]
+ SLICE[0].RAM8x32.WORD[2].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[2].W.B3.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[2].W.B3.BIT[1].OBUF
+ SLICE[0].RAM8x32.WORD[2].W.B3.q_wire[1] SLICE[0].RAM8x32.WORD[2].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[25] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[2].W.B3.BIT[2].LATCH SLICE[0].RAM8x32.Di[26]
+ SLICE[0].RAM8x32.WORD[2].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[2].W.B3.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[2].W.B3.BIT[2].OBUF
+ SLICE[0].RAM8x32.WORD[2].W.B3.q_wire[2] SLICE[0].RAM8x32.WORD[2].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[26] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[2].W.B3.BIT[3].LATCH SLICE[0].RAM8x32.Di[27]
+ SLICE[0].RAM8x32.WORD[2].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[2].W.B3.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[2].W.B3.BIT[3].OBUF
+ SLICE[0].RAM8x32.WORD[2].W.B3.q_wire[3] SLICE[0].RAM8x32.WORD[2].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[27] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[2].W.B3.BIT[4].LATCH SLICE[0].RAM8x32.Di[28]
+ SLICE[0].RAM8x32.WORD[2].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[2].W.B3.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[2].W.B3.BIT[4].OBUF
+ SLICE[0].RAM8x32.WORD[2].W.B3.q_wire[4] SLICE[0].RAM8x32.WORD[2].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[28] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[2].W.B3.BIT[5].LATCH SLICE[0].RAM8x32.Di[29]
+ SLICE[0].RAM8x32.WORD[2].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[2].W.B3.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[2].W.B3.BIT[5].OBUF
+ SLICE[0].RAM8x32.WORD[2].W.B3.q_wire[5] SLICE[0].RAM8x32.WORD[2].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[29] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[2].W.B3.BIT[6].LATCH SLICE[0].RAM8x32.Di[30]
+ SLICE[0].RAM8x32.WORD[2].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[2].W.B3.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[2].W.B3.BIT[6].OBUF
+ SLICE[0].RAM8x32.WORD[2].W.B3.q_wire[6] SLICE[0].RAM8x32.WORD[2].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[30] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[2].W.B3.BIT[7].LATCH SLICE[0].RAM8x32.Di[31]
+ SLICE[0].RAM8x32.WORD[2].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[2].W.B3.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[2].W.B3.BIT[7].OBUF
+ SLICE[0].RAM8x32.WORD[2].W.B3.q_wire[7] SLICE[0].RAM8x32.WORD[2].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[31] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[2].W.B3.CG SLICE[0].RAM8x32.WORD[2].W.B3.CLK_B
+ SLICE[0].RAM8x32.WORD[2].W.B3.we_wire VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[2].W.B3.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[0].RAM8x32.WORD[2].W.B3.CGAND SLICE[0].RAM8x32.WORD[2].W.B0.SEL
+ SLICE[0].RAM8x32.WORD[0].W.B3.WE VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[2].W.B3.we_wire sky130_fd_sc_hd__and2_1
XSLICE[0].RAM8x32.WORD[2].W.B3.CLKINV SLICE[0].RAM8x32.WORD[2].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[2].W.B3.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[2].W.B3.SELINV SLICE[0].RAM8x32.WORD[2].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[2].W.B3.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[2].W.CLKBUF SLICE[0].RAM8x32.CLK_buf VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[2].W.B0.CLK sky130_fd_sc_hd__clkbuf_1
XSLICE[0].RAM8x32.WORD[2].W.SELBUF SLICE[0].RAM8x32.WORD[2].W.SEL VGND VGND
+ VPWR VPWR SLICE[0].RAM8x32.WORD[2].W.B0.SEL sky130_fd_sc_hd__clkbuf_2
XSLICE[0].RAM8x32.WORD[3].W.B0.BIT[0].LATCH SLICE[0].RAM8x32.Di[0]
+ SLICE[0].RAM8x32.WORD[3].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[3].W.B0.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[3].W.B0.BIT[0].OBUF
+ SLICE[0].RAM8x32.WORD[3].W.B0.q_wire[0] SLICE[0].RAM8x32.WORD[3].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[0] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[3].W.B0.BIT[1].LATCH SLICE[0].RAM8x32.Di[1]
+ SLICE[0].RAM8x32.WORD[3].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[3].W.B0.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[3].W.B0.BIT[1].OBUF
+ SLICE[0].RAM8x32.WORD[3].W.B0.q_wire[1] SLICE[0].RAM8x32.WORD[3].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[1] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[3].W.B0.BIT[2].LATCH SLICE[0].RAM8x32.Di[2]
+ SLICE[0].RAM8x32.WORD[3].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[3].W.B0.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[3].W.B0.BIT[2].OBUF
+ SLICE[0].RAM8x32.WORD[3].W.B0.q_wire[2] SLICE[0].RAM8x32.WORD[3].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[2] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[3].W.B0.BIT[3].LATCH SLICE[0].RAM8x32.Di[3]
+ SLICE[0].RAM8x32.WORD[3].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[3].W.B0.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[3].W.B0.BIT[3].OBUF
+ SLICE[0].RAM8x32.WORD[3].W.B0.q_wire[3] SLICE[0].RAM8x32.WORD[3].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[3] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[3].W.B0.BIT[4].LATCH SLICE[0].RAM8x32.Di[4]
+ SLICE[0].RAM8x32.WORD[3].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[3].W.B0.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[3].W.B0.BIT[4].OBUF
+ SLICE[0].RAM8x32.WORD[3].W.B0.q_wire[4] SLICE[0].RAM8x32.WORD[3].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[4] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[3].W.B0.BIT[5].LATCH SLICE[0].RAM8x32.Di[5]
+ SLICE[0].RAM8x32.WORD[3].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[3].W.B0.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[3].W.B0.BIT[5].OBUF
+ SLICE[0].RAM8x32.WORD[3].W.B0.q_wire[5] SLICE[0].RAM8x32.WORD[3].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[5] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[3].W.B0.BIT[6].LATCH SLICE[0].RAM8x32.Di[6]
+ SLICE[0].RAM8x32.WORD[3].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[3].W.B0.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[3].W.B0.BIT[6].OBUF
+ SLICE[0].RAM8x32.WORD[3].W.B0.q_wire[6] SLICE[0].RAM8x32.WORD[3].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[6] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[3].W.B0.BIT[7].LATCH SLICE[0].RAM8x32.Di[7]
+ SLICE[0].RAM8x32.WORD[3].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[3].W.B0.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[3].W.B0.BIT[7].OBUF
+ SLICE[0].RAM8x32.WORD[3].W.B0.q_wire[7] SLICE[0].RAM8x32.WORD[3].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[7] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[3].W.B0.CG SLICE[0].RAM8x32.WORD[3].W.B0.CLK_B
+ SLICE[0].RAM8x32.WORD[3].W.B0.we_wire VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[3].W.B0.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[0].RAM8x32.WORD[3].W.B0.CGAND SLICE[0].RAM8x32.WORD[3].W.B0.SEL
+ SLICE[0].RAM8x32.WORD[0].W.B0.WE VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[3].W.B0.we_wire sky130_fd_sc_hd__and2_1
XSLICE[0].RAM8x32.WORD[3].W.B0.CLKINV SLICE[0].RAM8x32.WORD[3].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[3].W.B0.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[3].W.B0.SELINV SLICE[0].RAM8x32.WORD[3].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[3].W.B0.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[3].W.B1.BIT[0].LATCH SLICE[0].RAM8x32.Di[8]
+ SLICE[0].RAM8x32.WORD[3].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[3].W.B1.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[3].W.B1.BIT[0].OBUF
+ SLICE[0].RAM8x32.WORD[3].W.B1.q_wire[0] SLICE[0].RAM8x32.WORD[3].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[8] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[3].W.B1.BIT[1].LATCH SLICE[0].RAM8x32.Di[9]
+ SLICE[0].RAM8x32.WORD[3].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[3].W.B1.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[3].W.B1.BIT[1].OBUF
+ SLICE[0].RAM8x32.WORD[3].W.B1.q_wire[1] SLICE[0].RAM8x32.WORD[3].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[9] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[3].W.B1.BIT[2].LATCH SLICE[0].RAM8x32.Di[10]
+ SLICE[0].RAM8x32.WORD[3].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[3].W.B1.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[3].W.B1.BIT[2].OBUF
+ SLICE[0].RAM8x32.WORD[3].W.B1.q_wire[2] SLICE[0].RAM8x32.WORD[3].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[10] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[3].W.B1.BIT[3].LATCH SLICE[0].RAM8x32.Di[11]
+ SLICE[0].RAM8x32.WORD[3].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[3].W.B1.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[3].W.B1.BIT[3].OBUF
+ SLICE[0].RAM8x32.WORD[3].W.B1.q_wire[3] SLICE[0].RAM8x32.WORD[3].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[11] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[3].W.B1.BIT[4].LATCH SLICE[0].RAM8x32.Di[12]
+ SLICE[0].RAM8x32.WORD[3].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[3].W.B1.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[3].W.B1.BIT[4].OBUF
+ SLICE[0].RAM8x32.WORD[3].W.B1.q_wire[4] SLICE[0].RAM8x32.WORD[3].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[12] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[3].W.B1.BIT[5].LATCH SLICE[0].RAM8x32.Di[13]
+ SLICE[0].RAM8x32.WORD[3].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[3].W.B1.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[3].W.B1.BIT[5].OBUF
+ SLICE[0].RAM8x32.WORD[3].W.B1.q_wire[5] SLICE[0].RAM8x32.WORD[3].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[13] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[3].W.B1.BIT[6].LATCH SLICE[0].RAM8x32.Di[14]
+ SLICE[0].RAM8x32.WORD[3].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[3].W.B1.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[3].W.B1.BIT[6].OBUF
+ SLICE[0].RAM8x32.WORD[3].W.B1.q_wire[6] SLICE[0].RAM8x32.WORD[3].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[14] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[3].W.B1.BIT[7].LATCH SLICE[0].RAM8x32.Di[15]
+ SLICE[0].RAM8x32.WORD[3].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[3].W.B1.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[3].W.B1.BIT[7].OBUF
+ SLICE[0].RAM8x32.WORD[3].W.B1.q_wire[7] SLICE[0].RAM8x32.WORD[3].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[15] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[3].W.B1.CG SLICE[0].RAM8x32.WORD[3].W.B1.CLK_B
+ SLICE[0].RAM8x32.WORD[3].W.B1.we_wire VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[3].W.B1.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[0].RAM8x32.WORD[3].W.B1.CGAND SLICE[0].RAM8x32.WORD[3].W.B0.SEL
+ SLICE[0].RAM8x32.WORD[0].W.B1.WE VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[3].W.B1.we_wire sky130_fd_sc_hd__and2_1
XSLICE[0].RAM8x32.WORD[3].W.B1.CLKINV SLICE[0].RAM8x32.WORD[3].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[3].W.B1.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[3].W.B1.SELINV SLICE[0].RAM8x32.WORD[3].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[3].W.B1.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[3].W.B2.BIT[0].LATCH SLICE[0].RAM8x32.Di[16]
+ SLICE[0].RAM8x32.WORD[3].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[3].W.B2.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[3].W.B2.BIT[0].OBUF
+ SLICE[0].RAM8x32.WORD[3].W.B2.q_wire[0] SLICE[0].RAM8x32.WORD[3].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[16] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[3].W.B2.BIT[1].LATCH SLICE[0].RAM8x32.Di[17]
+ SLICE[0].RAM8x32.WORD[3].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[3].W.B2.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[3].W.B2.BIT[1].OBUF
+ SLICE[0].RAM8x32.WORD[3].W.B2.q_wire[1] SLICE[0].RAM8x32.WORD[3].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[17] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[3].W.B2.BIT[2].LATCH SLICE[0].RAM8x32.Di[18]
+ SLICE[0].RAM8x32.WORD[3].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[3].W.B2.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[3].W.B2.BIT[2].OBUF
+ SLICE[0].RAM8x32.WORD[3].W.B2.q_wire[2] SLICE[0].RAM8x32.WORD[3].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[18] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[3].W.B2.BIT[3].LATCH SLICE[0].RAM8x32.Di[19]
+ SLICE[0].RAM8x32.WORD[3].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[3].W.B2.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[3].W.B2.BIT[3].OBUF
+ SLICE[0].RAM8x32.WORD[3].W.B2.q_wire[3] SLICE[0].RAM8x32.WORD[3].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[19] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[3].W.B2.BIT[4].LATCH SLICE[0].RAM8x32.Di[20]
+ SLICE[0].RAM8x32.WORD[3].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[3].W.B2.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[3].W.B2.BIT[4].OBUF
+ SLICE[0].RAM8x32.WORD[3].W.B2.q_wire[4] SLICE[0].RAM8x32.WORD[3].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[20] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[3].W.B2.BIT[5].LATCH SLICE[0].RAM8x32.Di[21]
+ SLICE[0].RAM8x32.WORD[3].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[3].W.B2.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[3].W.B2.BIT[5].OBUF
+ SLICE[0].RAM8x32.WORD[3].W.B2.q_wire[5] SLICE[0].RAM8x32.WORD[3].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[21] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[3].W.B2.BIT[6].LATCH SLICE[0].RAM8x32.Di[22]
+ SLICE[0].RAM8x32.WORD[3].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[3].W.B2.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[3].W.B2.BIT[6].OBUF
+ SLICE[0].RAM8x32.WORD[3].W.B2.q_wire[6] SLICE[0].RAM8x32.WORD[3].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[22] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[3].W.B2.BIT[7].LATCH SLICE[0].RAM8x32.Di[23]
+ SLICE[0].RAM8x32.WORD[3].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[3].W.B2.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[3].W.B2.BIT[7].OBUF
+ SLICE[0].RAM8x32.WORD[3].W.B2.q_wire[7] SLICE[0].RAM8x32.WORD[3].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[23] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[3].W.B2.CG SLICE[0].RAM8x32.WORD[3].W.B2.CLK_B
+ SLICE[0].RAM8x32.WORD[3].W.B2.we_wire VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[3].W.B2.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[0].RAM8x32.WORD[3].W.B2.CGAND SLICE[0].RAM8x32.WORD[3].W.B0.SEL
+ SLICE[0].RAM8x32.WORD[0].W.B2.WE VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[3].W.B2.we_wire sky130_fd_sc_hd__and2_1
XSLICE[0].RAM8x32.WORD[3].W.B2.CLKINV SLICE[0].RAM8x32.WORD[3].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[3].W.B2.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[3].W.B2.SELINV SLICE[0].RAM8x32.WORD[3].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[3].W.B2.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[3].W.B3.BIT[0].LATCH SLICE[0].RAM8x32.Di[24]
+ SLICE[0].RAM8x32.WORD[3].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[3].W.B3.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[3].W.B3.BIT[0].OBUF
+ SLICE[0].RAM8x32.WORD[3].W.B3.q_wire[0] SLICE[0].RAM8x32.WORD[3].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[24] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[3].W.B3.BIT[1].LATCH SLICE[0].RAM8x32.Di[25]
+ SLICE[0].RAM8x32.WORD[3].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[3].W.B3.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[3].W.B3.BIT[1].OBUF
+ SLICE[0].RAM8x32.WORD[3].W.B3.q_wire[1] SLICE[0].RAM8x32.WORD[3].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[25] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[3].W.B3.BIT[2].LATCH SLICE[0].RAM8x32.Di[26]
+ SLICE[0].RAM8x32.WORD[3].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[3].W.B3.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[3].W.B3.BIT[2].OBUF
+ SLICE[0].RAM8x32.WORD[3].W.B3.q_wire[2] SLICE[0].RAM8x32.WORD[3].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[26] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[3].W.B3.BIT[3].LATCH SLICE[0].RAM8x32.Di[27]
+ SLICE[0].RAM8x32.WORD[3].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[3].W.B3.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[3].W.B3.BIT[3].OBUF
+ SLICE[0].RAM8x32.WORD[3].W.B3.q_wire[3] SLICE[0].RAM8x32.WORD[3].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[27] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[3].W.B3.BIT[4].LATCH SLICE[0].RAM8x32.Di[28]
+ SLICE[0].RAM8x32.WORD[3].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[3].W.B3.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[3].W.B3.BIT[4].OBUF
+ SLICE[0].RAM8x32.WORD[3].W.B3.q_wire[4] SLICE[0].RAM8x32.WORD[3].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[28] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[3].W.B3.BIT[5].LATCH SLICE[0].RAM8x32.Di[29]
+ SLICE[0].RAM8x32.WORD[3].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[3].W.B3.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[3].W.B3.BIT[5].OBUF
+ SLICE[0].RAM8x32.WORD[3].W.B3.q_wire[5] SLICE[0].RAM8x32.WORD[3].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[29] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[3].W.B3.BIT[6].LATCH SLICE[0].RAM8x32.Di[30]
+ SLICE[0].RAM8x32.WORD[3].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[3].W.B3.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[3].W.B3.BIT[6].OBUF
+ SLICE[0].RAM8x32.WORD[3].W.B3.q_wire[6] SLICE[0].RAM8x32.WORD[3].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[30] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[3].W.B3.BIT[7].LATCH SLICE[0].RAM8x32.Di[31]
+ SLICE[0].RAM8x32.WORD[3].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[3].W.B3.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[3].W.B3.BIT[7].OBUF
+ SLICE[0].RAM8x32.WORD[3].W.B3.q_wire[7] SLICE[0].RAM8x32.WORD[3].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[31] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[3].W.B3.CG SLICE[0].RAM8x32.WORD[3].W.B3.CLK_B
+ SLICE[0].RAM8x32.WORD[3].W.B3.we_wire VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[3].W.B3.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[0].RAM8x32.WORD[3].W.B3.CGAND SLICE[0].RAM8x32.WORD[3].W.B0.SEL
+ SLICE[0].RAM8x32.WORD[0].W.B3.WE VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[3].W.B3.we_wire sky130_fd_sc_hd__and2_1
XSLICE[0].RAM8x32.WORD[3].W.B3.CLKINV SLICE[0].RAM8x32.WORD[3].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[3].W.B3.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[3].W.B3.SELINV SLICE[0].RAM8x32.WORD[3].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[3].W.B3.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[3].W.CLKBUF SLICE[0].RAM8x32.CLK_buf VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[3].W.B0.CLK sky130_fd_sc_hd__clkbuf_1
XSLICE[0].RAM8x32.WORD[3].W.SELBUF SLICE[0].RAM8x32.WORD[3].W.SEL VGND VGND
+ VPWR VPWR SLICE[0].RAM8x32.WORD[3].W.B0.SEL sky130_fd_sc_hd__clkbuf_2
XSLICE[0].RAM8x32.WORD[4].W.B0.BIT[0].LATCH SLICE[0].RAM8x32.Di[0]
+ SLICE[0].RAM8x32.WORD[4].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[4].W.B0.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[4].W.B0.BIT[0].OBUF
+ SLICE[0].RAM8x32.WORD[4].W.B0.q_wire[0] SLICE[0].RAM8x32.WORD[4].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[0] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[4].W.B0.BIT[1].LATCH SLICE[0].RAM8x32.Di[1]
+ SLICE[0].RAM8x32.WORD[4].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[4].W.B0.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[4].W.B0.BIT[1].OBUF
+ SLICE[0].RAM8x32.WORD[4].W.B0.q_wire[1] SLICE[0].RAM8x32.WORD[4].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[1] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[4].W.B0.BIT[2].LATCH SLICE[0].RAM8x32.Di[2]
+ SLICE[0].RAM8x32.WORD[4].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[4].W.B0.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[4].W.B0.BIT[2].OBUF
+ SLICE[0].RAM8x32.WORD[4].W.B0.q_wire[2] SLICE[0].RAM8x32.WORD[4].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[2] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[4].W.B0.BIT[3].LATCH SLICE[0].RAM8x32.Di[3]
+ SLICE[0].RAM8x32.WORD[4].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[4].W.B0.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[4].W.B0.BIT[3].OBUF
+ SLICE[0].RAM8x32.WORD[4].W.B0.q_wire[3] SLICE[0].RAM8x32.WORD[4].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[3] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[4].W.B0.BIT[4].LATCH SLICE[0].RAM8x32.Di[4]
+ SLICE[0].RAM8x32.WORD[4].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[4].W.B0.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[4].W.B0.BIT[4].OBUF
+ SLICE[0].RAM8x32.WORD[4].W.B0.q_wire[4] SLICE[0].RAM8x32.WORD[4].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[4] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[4].W.B0.BIT[5].LATCH SLICE[0].RAM8x32.Di[5]
+ SLICE[0].RAM8x32.WORD[4].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[4].W.B0.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[4].W.B0.BIT[5].OBUF
+ SLICE[0].RAM8x32.WORD[4].W.B0.q_wire[5] SLICE[0].RAM8x32.WORD[4].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[5] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[4].W.B0.BIT[6].LATCH SLICE[0].RAM8x32.Di[6]
+ SLICE[0].RAM8x32.WORD[4].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[4].W.B0.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[4].W.B0.BIT[6].OBUF
+ SLICE[0].RAM8x32.WORD[4].W.B0.q_wire[6] SLICE[0].RAM8x32.WORD[4].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[6] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[4].W.B0.BIT[7].LATCH SLICE[0].RAM8x32.Di[7]
+ SLICE[0].RAM8x32.WORD[4].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[4].W.B0.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[4].W.B0.BIT[7].OBUF
+ SLICE[0].RAM8x32.WORD[4].W.B0.q_wire[7] SLICE[0].RAM8x32.WORD[4].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[7] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[4].W.B0.CG SLICE[0].RAM8x32.WORD[4].W.B0.CLK_B
+ SLICE[0].RAM8x32.WORD[4].W.B0.we_wire VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[4].W.B0.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[0].RAM8x32.WORD[4].W.B0.CGAND SLICE[0].RAM8x32.WORD[4].W.B0.SEL
+ SLICE[0].RAM8x32.WORD[0].W.B0.WE VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[4].W.B0.we_wire sky130_fd_sc_hd__and2_1
XSLICE[0].RAM8x32.WORD[4].W.B0.CLKINV SLICE[0].RAM8x32.WORD[4].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[4].W.B0.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[4].W.B0.SELINV SLICE[0].RAM8x32.WORD[4].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[4].W.B0.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[4].W.B1.BIT[0].LATCH SLICE[0].RAM8x32.Di[8]
+ SLICE[0].RAM8x32.WORD[4].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[4].W.B1.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[4].W.B1.BIT[0].OBUF
+ SLICE[0].RAM8x32.WORD[4].W.B1.q_wire[0] SLICE[0].RAM8x32.WORD[4].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[8] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[4].W.B1.BIT[1].LATCH SLICE[0].RAM8x32.Di[9]
+ SLICE[0].RAM8x32.WORD[4].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[4].W.B1.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[4].W.B1.BIT[1].OBUF
+ SLICE[0].RAM8x32.WORD[4].W.B1.q_wire[1] SLICE[0].RAM8x32.WORD[4].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[9] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[4].W.B1.BIT[2].LATCH SLICE[0].RAM8x32.Di[10]
+ SLICE[0].RAM8x32.WORD[4].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[4].W.B1.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[4].W.B1.BIT[2].OBUF
+ SLICE[0].RAM8x32.WORD[4].W.B1.q_wire[2] SLICE[0].RAM8x32.WORD[4].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[10] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[4].W.B1.BIT[3].LATCH SLICE[0].RAM8x32.Di[11]
+ SLICE[0].RAM8x32.WORD[4].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[4].W.B1.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[4].W.B1.BIT[3].OBUF
+ SLICE[0].RAM8x32.WORD[4].W.B1.q_wire[3] SLICE[0].RAM8x32.WORD[4].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[11] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[4].W.B1.BIT[4].LATCH SLICE[0].RAM8x32.Di[12]
+ SLICE[0].RAM8x32.WORD[4].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[4].W.B1.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[4].W.B1.BIT[4].OBUF
+ SLICE[0].RAM8x32.WORD[4].W.B1.q_wire[4] SLICE[0].RAM8x32.WORD[4].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[12] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[4].W.B1.BIT[5].LATCH SLICE[0].RAM8x32.Di[13]
+ SLICE[0].RAM8x32.WORD[4].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[4].W.B1.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[4].W.B1.BIT[5].OBUF
+ SLICE[0].RAM8x32.WORD[4].W.B1.q_wire[5] SLICE[0].RAM8x32.WORD[4].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[13] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[4].W.B1.BIT[6].LATCH SLICE[0].RAM8x32.Di[14]
+ SLICE[0].RAM8x32.WORD[4].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[4].W.B1.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[4].W.B1.BIT[6].OBUF
+ SLICE[0].RAM8x32.WORD[4].W.B1.q_wire[6] SLICE[0].RAM8x32.WORD[4].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[14] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[4].W.B1.BIT[7].LATCH SLICE[0].RAM8x32.Di[15]
+ SLICE[0].RAM8x32.WORD[4].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[4].W.B1.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[4].W.B1.BIT[7].OBUF
+ SLICE[0].RAM8x32.WORD[4].W.B1.q_wire[7] SLICE[0].RAM8x32.WORD[4].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[15] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[4].W.B1.CG SLICE[0].RAM8x32.WORD[4].W.B1.CLK_B
+ SLICE[0].RAM8x32.WORD[4].W.B1.we_wire VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[4].W.B1.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[0].RAM8x32.WORD[4].W.B1.CGAND SLICE[0].RAM8x32.WORD[4].W.B0.SEL
+ SLICE[0].RAM8x32.WORD[0].W.B1.WE VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[4].W.B1.we_wire sky130_fd_sc_hd__and2_1
XSLICE[0].RAM8x32.WORD[4].W.B1.CLKINV SLICE[0].RAM8x32.WORD[4].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[4].W.B1.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[4].W.B1.SELINV SLICE[0].RAM8x32.WORD[4].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[4].W.B1.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[4].W.B2.BIT[0].LATCH SLICE[0].RAM8x32.Di[16]
+ SLICE[0].RAM8x32.WORD[4].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[4].W.B2.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[4].W.B2.BIT[0].OBUF
+ SLICE[0].RAM8x32.WORD[4].W.B2.q_wire[0] SLICE[0].RAM8x32.WORD[4].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[16] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[4].W.B2.BIT[1].LATCH SLICE[0].RAM8x32.Di[17]
+ SLICE[0].RAM8x32.WORD[4].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[4].W.B2.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[4].W.B2.BIT[1].OBUF
+ SLICE[0].RAM8x32.WORD[4].W.B2.q_wire[1] SLICE[0].RAM8x32.WORD[4].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[17] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[4].W.B2.BIT[2].LATCH SLICE[0].RAM8x32.Di[18]
+ SLICE[0].RAM8x32.WORD[4].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[4].W.B2.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[4].W.B2.BIT[2].OBUF
+ SLICE[0].RAM8x32.WORD[4].W.B2.q_wire[2] SLICE[0].RAM8x32.WORD[4].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[18] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[4].W.B2.BIT[3].LATCH SLICE[0].RAM8x32.Di[19]
+ SLICE[0].RAM8x32.WORD[4].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[4].W.B2.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[4].W.B2.BIT[3].OBUF
+ SLICE[0].RAM8x32.WORD[4].W.B2.q_wire[3] SLICE[0].RAM8x32.WORD[4].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[19] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[4].W.B2.BIT[4].LATCH SLICE[0].RAM8x32.Di[20]
+ SLICE[0].RAM8x32.WORD[4].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[4].W.B2.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[4].W.B2.BIT[4].OBUF
+ SLICE[0].RAM8x32.WORD[4].W.B2.q_wire[4] SLICE[0].RAM8x32.WORD[4].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[20] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[4].W.B2.BIT[5].LATCH SLICE[0].RAM8x32.Di[21]
+ SLICE[0].RAM8x32.WORD[4].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[4].W.B2.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[4].W.B2.BIT[5].OBUF
+ SLICE[0].RAM8x32.WORD[4].W.B2.q_wire[5] SLICE[0].RAM8x32.WORD[4].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[21] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[4].W.B2.BIT[6].LATCH SLICE[0].RAM8x32.Di[22]
+ SLICE[0].RAM8x32.WORD[4].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[4].W.B2.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[4].W.B2.BIT[6].OBUF
+ SLICE[0].RAM8x32.WORD[4].W.B2.q_wire[6] SLICE[0].RAM8x32.WORD[4].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[22] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[4].W.B2.BIT[7].LATCH SLICE[0].RAM8x32.Di[23]
+ SLICE[0].RAM8x32.WORD[4].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[4].W.B2.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[4].W.B2.BIT[7].OBUF
+ SLICE[0].RAM8x32.WORD[4].W.B2.q_wire[7] SLICE[0].RAM8x32.WORD[4].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[23] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[4].W.B2.CG SLICE[0].RAM8x32.WORD[4].W.B2.CLK_B
+ SLICE[0].RAM8x32.WORD[4].W.B2.we_wire VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[4].W.B2.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[0].RAM8x32.WORD[4].W.B2.CGAND SLICE[0].RAM8x32.WORD[4].W.B0.SEL
+ SLICE[0].RAM8x32.WORD[0].W.B2.WE VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[4].W.B2.we_wire sky130_fd_sc_hd__and2_1
XSLICE[0].RAM8x32.WORD[4].W.B2.CLKINV SLICE[0].RAM8x32.WORD[4].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[4].W.B2.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[4].W.B2.SELINV SLICE[0].RAM8x32.WORD[4].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[4].W.B2.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[4].W.B3.BIT[0].LATCH SLICE[0].RAM8x32.Di[24]
+ SLICE[0].RAM8x32.WORD[4].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[4].W.B3.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[4].W.B3.BIT[0].OBUF
+ SLICE[0].RAM8x32.WORD[4].W.B3.q_wire[0] SLICE[0].RAM8x32.WORD[4].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[24] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[4].W.B3.BIT[1].LATCH SLICE[0].RAM8x32.Di[25]
+ SLICE[0].RAM8x32.WORD[4].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[4].W.B3.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[4].W.B3.BIT[1].OBUF
+ SLICE[0].RAM8x32.WORD[4].W.B3.q_wire[1] SLICE[0].RAM8x32.WORD[4].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[25] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[4].W.B3.BIT[2].LATCH SLICE[0].RAM8x32.Di[26]
+ SLICE[0].RAM8x32.WORD[4].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[4].W.B3.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[4].W.B3.BIT[2].OBUF
+ SLICE[0].RAM8x32.WORD[4].W.B3.q_wire[2] SLICE[0].RAM8x32.WORD[4].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[26] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[4].W.B3.BIT[3].LATCH SLICE[0].RAM8x32.Di[27]
+ SLICE[0].RAM8x32.WORD[4].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[4].W.B3.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[4].W.B3.BIT[3].OBUF
+ SLICE[0].RAM8x32.WORD[4].W.B3.q_wire[3] SLICE[0].RAM8x32.WORD[4].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[27] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[4].W.B3.BIT[4].LATCH SLICE[0].RAM8x32.Di[28]
+ SLICE[0].RAM8x32.WORD[4].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[4].W.B3.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[4].W.B3.BIT[4].OBUF
+ SLICE[0].RAM8x32.WORD[4].W.B3.q_wire[4] SLICE[0].RAM8x32.WORD[4].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[28] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[4].W.B3.BIT[5].LATCH SLICE[0].RAM8x32.Di[29]
+ SLICE[0].RAM8x32.WORD[4].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[4].W.B3.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[4].W.B3.BIT[5].OBUF
+ SLICE[0].RAM8x32.WORD[4].W.B3.q_wire[5] SLICE[0].RAM8x32.WORD[4].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[29] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[4].W.B3.BIT[6].LATCH SLICE[0].RAM8x32.Di[30]
+ SLICE[0].RAM8x32.WORD[4].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[4].W.B3.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[4].W.B3.BIT[6].OBUF
+ SLICE[0].RAM8x32.WORD[4].W.B3.q_wire[6] SLICE[0].RAM8x32.WORD[4].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[30] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[4].W.B3.BIT[7].LATCH SLICE[0].RAM8x32.Di[31]
+ SLICE[0].RAM8x32.WORD[4].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[4].W.B3.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[4].W.B3.BIT[7].OBUF
+ SLICE[0].RAM8x32.WORD[4].W.B3.q_wire[7] SLICE[0].RAM8x32.WORD[4].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[31] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[4].W.B3.CG SLICE[0].RAM8x32.WORD[4].W.B3.CLK_B
+ SLICE[0].RAM8x32.WORD[4].W.B3.we_wire VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[4].W.B3.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[0].RAM8x32.WORD[4].W.B3.CGAND SLICE[0].RAM8x32.WORD[4].W.B0.SEL
+ SLICE[0].RAM8x32.WORD[0].W.B3.WE VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[4].W.B3.we_wire sky130_fd_sc_hd__and2_1
XSLICE[0].RAM8x32.WORD[4].W.B3.CLKINV SLICE[0].RAM8x32.WORD[4].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[4].W.B3.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[4].W.B3.SELINV SLICE[0].RAM8x32.WORD[4].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[4].W.B3.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[4].W.CLKBUF SLICE[0].RAM8x32.CLK_buf VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[4].W.B0.CLK sky130_fd_sc_hd__clkbuf_1
XSLICE[0].RAM8x32.WORD[4].W.SELBUF SLICE[0].RAM8x32.WORD[4].W.SEL VGND VGND
+ VPWR VPWR SLICE[0].RAM8x32.WORD[4].W.B0.SEL sky130_fd_sc_hd__clkbuf_2
XSLICE[0].RAM8x32.WORD[5].W.B0.BIT[0].LATCH SLICE[0].RAM8x32.Di[0]
+ SLICE[0].RAM8x32.WORD[5].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[5].W.B0.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[5].W.B0.BIT[0].OBUF
+ SLICE[0].RAM8x32.WORD[5].W.B0.q_wire[0] SLICE[0].RAM8x32.WORD[5].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[0] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[5].W.B0.BIT[1].LATCH SLICE[0].RAM8x32.Di[1]
+ SLICE[0].RAM8x32.WORD[5].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[5].W.B0.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[5].W.B0.BIT[1].OBUF
+ SLICE[0].RAM8x32.WORD[5].W.B0.q_wire[1] SLICE[0].RAM8x32.WORD[5].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[1] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[5].W.B0.BIT[2].LATCH SLICE[0].RAM8x32.Di[2]
+ SLICE[0].RAM8x32.WORD[5].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[5].W.B0.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[5].W.B0.BIT[2].OBUF
+ SLICE[0].RAM8x32.WORD[5].W.B0.q_wire[2] SLICE[0].RAM8x32.WORD[5].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[2] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[5].W.B0.BIT[3].LATCH SLICE[0].RAM8x32.Di[3]
+ SLICE[0].RAM8x32.WORD[5].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[5].W.B0.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[5].W.B0.BIT[3].OBUF
+ SLICE[0].RAM8x32.WORD[5].W.B0.q_wire[3] SLICE[0].RAM8x32.WORD[5].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[3] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[5].W.B0.BIT[4].LATCH SLICE[0].RAM8x32.Di[4]
+ SLICE[0].RAM8x32.WORD[5].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[5].W.B0.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[5].W.B0.BIT[4].OBUF
+ SLICE[0].RAM8x32.WORD[5].W.B0.q_wire[4] SLICE[0].RAM8x32.WORD[5].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[4] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[5].W.B0.BIT[5].LATCH SLICE[0].RAM8x32.Di[5]
+ SLICE[0].RAM8x32.WORD[5].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[5].W.B0.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[5].W.B0.BIT[5].OBUF
+ SLICE[0].RAM8x32.WORD[5].W.B0.q_wire[5] SLICE[0].RAM8x32.WORD[5].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[5] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[5].W.B0.BIT[6].LATCH SLICE[0].RAM8x32.Di[6]
+ SLICE[0].RAM8x32.WORD[5].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[5].W.B0.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[5].W.B0.BIT[6].OBUF
+ SLICE[0].RAM8x32.WORD[5].W.B0.q_wire[6] SLICE[0].RAM8x32.WORD[5].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[6] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[5].W.B0.BIT[7].LATCH SLICE[0].RAM8x32.Di[7]
+ SLICE[0].RAM8x32.WORD[5].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[5].W.B0.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[5].W.B0.BIT[7].OBUF
+ SLICE[0].RAM8x32.WORD[5].W.B0.q_wire[7] SLICE[0].RAM8x32.WORD[5].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[7] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[5].W.B0.CG SLICE[0].RAM8x32.WORD[5].W.B0.CLK_B
+ SLICE[0].RAM8x32.WORD[5].W.B0.we_wire VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[5].W.B0.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[0].RAM8x32.WORD[5].W.B0.CGAND SLICE[0].RAM8x32.WORD[5].W.B0.SEL
+ SLICE[0].RAM8x32.WORD[0].W.B0.WE VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[5].W.B0.we_wire sky130_fd_sc_hd__and2_1
XSLICE[0].RAM8x32.WORD[5].W.B0.CLKINV SLICE[0].RAM8x32.WORD[5].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[5].W.B0.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[5].W.B0.SELINV SLICE[0].RAM8x32.WORD[5].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[5].W.B0.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[5].W.B1.BIT[0].LATCH SLICE[0].RAM8x32.Di[8]
+ SLICE[0].RAM8x32.WORD[5].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[5].W.B1.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[5].W.B1.BIT[0].OBUF
+ SLICE[0].RAM8x32.WORD[5].W.B1.q_wire[0] SLICE[0].RAM8x32.WORD[5].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[8] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[5].W.B1.BIT[1].LATCH SLICE[0].RAM8x32.Di[9]
+ SLICE[0].RAM8x32.WORD[5].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[5].W.B1.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[5].W.B1.BIT[1].OBUF
+ SLICE[0].RAM8x32.WORD[5].W.B1.q_wire[1] SLICE[0].RAM8x32.WORD[5].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[9] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[5].W.B1.BIT[2].LATCH SLICE[0].RAM8x32.Di[10]
+ SLICE[0].RAM8x32.WORD[5].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[5].W.B1.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[5].W.B1.BIT[2].OBUF
+ SLICE[0].RAM8x32.WORD[5].W.B1.q_wire[2] SLICE[0].RAM8x32.WORD[5].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[10] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[5].W.B1.BIT[3].LATCH SLICE[0].RAM8x32.Di[11]
+ SLICE[0].RAM8x32.WORD[5].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[5].W.B1.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[5].W.B1.BIT[3].OBUF
+ SLICE[0].RAM8x32.WORD[5].W.B1.q_wire[3] SLICE[0].RAM8x32.WORD[5].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[11] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[5].W.B1.BIT[4].LATCH SLICE[0].RAM8x32.Di[12]
+ SLICE[0].RAM8x32.WORD[5].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[5].W.B1.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[5].W.B1.BIT[4].OBUF
+ SLICE[0].RAM8x32.WORD[5].W.B1.q_wire[4] SLICE[0].RAM8x32.WORD[5].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[12] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[5].W.B1.BIT[5].LATCH SLICE[0].RAM8x32.Di[13]
+ SLICE[0].RAM8x32.WORD[5].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[5].W.B1.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[5].W.B1.BIT[5].OBUF
+ SLICE[0].RAM8x32.WORD[5].W.B1.q_wire[5] SLICE[0].RAM8x32.WORD[5].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[13] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[5].W.B1.BIT[6].LATCH SLICE[0].RAM8x32.Di[14]
+ SLICE[0].RAM8x32.WORD[5].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[5].W.B1.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[5].W.B1.BIT[6].OBUF
+ SLICE[0].RAM8x32.WORD[5].W.B1.q_wire[6] SLICE[0].RAM8x32.WORD[5].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[14] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[5].W.B1.BIT[7].LATCH SLICE[0].RAM8x32.Di[15]
+ SLICE[0].RAM8x32.WORD[5].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[5].W.B1.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[5].W.B1.BIT[7].OBUF
+ SLICE[0].RAM8x32.WORD[5].W.B1.q_wire[7] SLICE[0].RAM8x32.WORD[5].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[15] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[5].W.B1.CG SLICE[0].RAM8x32.WORD[5].W.B1.CLK_B
+ SLICE[0].RAM8x32.WORD[5].W.B1.we_wire VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[5].W.B1.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[0].RAM8x32.WORD[5].W.B1.CGAND SLICE[0].RAM8x32.WORD[5].W.B0.SEL
+ SLICE[0].RAM8x32.WORD[0].W.B1.WE VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[5].W.B1.we_wire sky130_fd_sc_hd__and2_1
XSLICE[0].RAM8x32.WORD[5].W.B1.CLKINV SLICE[0].RAM8x32.WORD[5].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[5].W.B1.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[5].W.B1.SELINV SLICE[0].RAM8x32.WORD[5].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[5].W.B1.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[5].W.B2.BIT[0].LATCH SLICE[0].RAM8x32.Di[16]
+ SLICE[0].RAM8x32.WORD[5].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[5].W.B2.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[5].W.B2.BIT[0].OBUF
+ SLICE[0].RAM8x32.WORD[5].W.B2.q_wire[0] SLICE[0].RAM8x32.WORD[5].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[16] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[5].W.B2.BIT[1].LATCH SLICE[0].RAM8x32.Di[17]
+ SLICE[0].RAM8x32.WORD[5].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[5].W.B2.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[5].W.B2.BIT[1].OBUF
+ SLICE[0].RAM8x32.WORD[5].W.B2.q_wire[1] SLICE[0].RAM8x32.WORD[5].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[17] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[5].W.B2.BIT[2].LATCH SLICE[0].RAM8x32.Di[18]
+ SLICE[0].RAM8x32.WORD[5].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[5].W.B2.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[5].W.B2.BIT[2].OBUF
+ SLICE[0].RAM8x32.WORD[5].W.B2.q_wire[2] SLICE[0].RAM8x32.WORD[5].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[18] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[5].W.B2.BIT[3].LATCH SLICE[0].RAM8x32.Di[19]
+ SLICE[0].RAM8x32.WORD[5].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[5].W.B2.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[5].W.B2.BIT[3].OBUF
+ SLICE[0].RAM8x32.WORD[5].W.B2.q_wire[3] SLICE[0].RAM8x32.WORD[5].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[19] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[5].W.B2.BIT[4].LATCH SLICE[0].RAM8x32.Di[20]
+ SLICE[0].RAM8x32.WORD[5].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[5].W.B2.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[5].W.B2.BIT[4].OBUF
+ SLICE[0].RAM8x32.WORD[5].W.B2.q_wire[4] SLICE[0].RAM8x32.WORD[5].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[20] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[5].W.B2.BIT[5].LATCH SLICE[0].RAM8x32.Di[21]
+ SLICE[0].RAM8x32.WORD[5].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[5].W.B2.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[5].W.B2.BIT[5].OBUF
+ SLICE[0].RAM8x32.WORD[5].W.B2.q_wire[5] SLICE[0].RAM8x32.WORD[5].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[21] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[5].W.B2.BIT[6].LATCH SLICE[0].RAM8x32.Di[22]
+ SLICE[0].RAM8x32.WORD[5].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[5].W.B2.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[5].W.B2.BIT[6].OBUF
+ SLICE[0].RAM8x32.WORD[5].W.B2.q_wire[6] SLICE[0].RAM8x32.WORD[5].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[22] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[5].W.B2.BIT[7].LATCH SLICE[0].RAM8x32.Di[23]
+ SLICE[0].RAM8x32.WORD[5].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[5].W.B2.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[5].W.B2.BIT[7].OBUF
+ SLICE[0].RAM8x32.WORD[5].W.B2.q_wire[7] SLICE[0].RAM8x32.WORD[5].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[23] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[5].W.B2.CG SLICE[0].RAM8x32.WORD[5].W.B2.CLK_B
+ SLICE[0].RAM8x32.WORD[5].W.B2.we_wire VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[5].W.B2.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[0].RAM8x32.WORD[5].W.B2.CGAND SLICE[0].RAM8x32.WORD[5].W.B0.SEL
+ SLICE[0].RAM8x32.WORD[0].W.B2.WE VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[5].W.B2.we_wire sky130_fd_sc_hd__and2_1
XSLICE[0].RAM8x32.WORD[5].W.B2.CLKINV SLICE[0].RAM8x32.WORD[5].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[5].W.B2.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[5].W.B2.SELINV SLICE[0].RAM8x32.WORD[5].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[5].W.B2.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[5].W.B3.BIT[0].LATCH SLICE[0].RAM8x32.Di[24]
+ SLICE[0].RAM8x32.WORD[5].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[5].W.B3.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[5].W.B3.BIT[0].OBUF
+ SLICE[0].RAM8x32.WORD[5].W.B3.q_wire[0] SLICE[0].RAM8x32.WORD[5].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[24] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[5].W.B3.BIT[1].LATCH SLICE[0].RAM8x32.Di[25]
+ SLICE[0].RAM8x32.WORD[5].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[5].W.B3.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[5].W.B3.BIT[1].OBUF
+ SLICE[0].RAM8x32.WORD[5].W.B3.q_wire[1] SLICE[0].RAM8x32.WORD[5].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[25] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[5].W.B3.BIT[2].LATCH SLICE[0].RAM8x32.Di[26]
+ SLICE[0].RAM8x32.WORD[5].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[5].W.B3.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[5].W.B3.BIT[2].OBUF
+ SLICE[0].RAM8x32.WORD[5].W.B3.q_wire[2] SLICE[0].RAM8x32.WORD[5].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[26] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[5].W.B3.BIT[3].LATCH SLICE[0].RAM8x32.Di[27]
+ SLICE[0].RAM8x32.WORD[5].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[5].W.B3.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[5].W.B3.BIT[3].OBUF
+ SLICE[0].RAM8x32.WORD[5].W.B3.q_wire[3] SLICE[0].RAM8x32.WORD[5].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[27] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[5].W.B3.BIT[4].LATCH SLICE[0].RAM8x32.Di[28]
+ SLICE[0].RAM8x32.WORD[5].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[5].W.B3.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[5].W.B3.BIT[4].OBUF
+ SLICE[0].RAM8x32.WORD[5].W.B3.q_wire[4] SLICE[0].RAM8x32.WORD[5].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[28] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[5].W.B3.BIT[5].LATCH SLICE[0].RAM8x32.Di[29]
+ SLICE[0].RAM8x32.WORD[5].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[5].W.B3.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[5].W.B3.BIT[5].OBUF
+ SLICE[0].RAM8x32.WORD[5].W.B3.q_wire[5] SLICE[0].RAM8x32.WORD[5].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[29] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[5].W.B3.BIT[6].LATCH SLICE[0].RAM8x32.Di[30]
+ SLICE[0].RAM8x32.WORD[5].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[5].W.B3.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[5].W.B3.BIT[6].OBUF
+ SLICE[0].RAM8x32.WORD[5].W.B3.q_wire[6] SLICE[0].RAM8x32.WORD[5].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[30] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[5].W.B3.BIT[7].LATCH SLICE[0].RAM8x32.Di[31]
+ SLICE[0].RAM8x32.WORD[5].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[5].W.B3.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[5].W.B3.BIT[7].OBUF
+ SLICE[0].RAM8x32.WORD[5].W.B3.q_wire[7] SLICE[0].RAM8x32.WORD[5].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[31] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[5].W.B3.CG SLICE[0].RAM8x32.WORD[5].W.B3.CLK_B
+ SLICE[0].RAM8x32.WORD[5].W.B3.we_wire VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[5].W.B3.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[0].RAM8x32.WORD[5].W.B3.CGAND SLICE[0].RAM8x32.WORD[5].W.B0.SEL
+ SLICE[0].RAM8x32.WORD[0].W.B3.WE VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[5].W.B3.we_wire sky130_fd_sc_hd__and2_1
XSLICE[0].RAM8x32.WORD[5].W.B3.CLKINV SLICE[0].RAM8x32.WORD[5].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[5].W.B3.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[5].W.B3.SELINV SLICE[0].RAM8x32.WORD[5].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[5].W.B3.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[5].W.CLKBUF SLICE[0].RAM8x32.CLK_buf VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[5].W.B0.CLK sky130_fd_sc_hd__clkbuf_1
XSLICE[0].RAM8x32.WORD[5].W.SELBUF SLICE[0].RAM8x32.WORD[5].W.SEL VGND VGND
+ VPWR VPWR SLICE[0].RAM8x32.WORD[5].W.B0.SEL sky130_fd_sc_hd__clkbuf_2
XSLICE[0].RAM8x32.WORD[6].W.B0.BIT[0].LATCH SLICE[0].RAM8x32.Di[0]
+ SLICE[0].RAM8x32.WORD[6].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[6].W.B0.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[6].W.B0.BIT[0].OBUF
+ SLICE[0].RAM8x32.WORD[6].W.B0.q_wire[0] SLICE[0].RAM8x32.WORD[6].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[0] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[6].W.B0.BIT[1].LATCH SLICE[0].RAM8x32.Di[1]
+ SLICE[0].RAM8x32.WORD[6].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[6].W.B0.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[6].W.B0.BIT[1].OBUF
+ SLICE[0].RAM8x32.WORD[6].W.B0.q_wire[1] SLICE[0].RAM8x32.WORD[6].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[1] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[6].W.B0.BIT[2].LATCH SLICE[0].RAM8x32.Di[2]
+ SLICE[0].RAM8x32.WORD[6].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[6].W.B0.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[6].W.B0.BIT[2].OBUF
+ SLICE[0].RAM8x32.WORD[6].W.B0.q_wire[2] SLICE[0].RAM8x32.WORD[6].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[2] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[6].W.B0.BIT[3].LATCH SLICE[0].RAM8x32.Di[3]
+ SLICE[0].RAM8x32.WORD[6].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[6].W.B0.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[6].W.B0.BIT[3].OBUF
+ SLICE[0].RAM8x32.WORD[6].W.B0.q_wire[3] SLICE[0].RAM8x32.WORD[6].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[3] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[6].W.B0.BIT[4].LATCH SLICE[0].RAM8x32.Di[4]
+ SLICE[0].RAM8x32.WORD[6].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[6].W.B0.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[6].W.B0.BIT[4].OBUF
+ SLICE[0].RAM8x32.WORD[6].W.B0.q_wire[4] SLICE[0].RAM8x32.WORD[6].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[4] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[6].W.B0.BIT[5].LATCH SLICE[0].RAM8x32.Di[5]
+ SLICE[0].RAM8x32.WORD[6].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[6].W.B0.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[6].W.B0.BIT[5].OBUF
+ SLICE[0].RAM8x32.WORD[6].W.B0.q_wire[5] SLICE[0].RAM8x32.WORD[6].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[5] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[6].W.B0.BIT[6].LATCH SLICE[0].RAM8x32.Di[6]
+ SLICE[0].RAM8x32.WORD[6].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[6].W.B0.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[6].W.B0.BIT[6].OBUF
+ SLICE[0].RAM8x32.WORD[6].W.B0.q_wire[6] SLICE[0].RAM8x32.WORD[6].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[6] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[6].W.B0.BIT[7].LATCH SLICE[0].RAM8x32.Di[7]
+ SLICE[0].RAM8x32.WORD[6].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[6].W.B0.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[6].W.B0.BIT[7].OBUF
+ SLICE[0].RAM8x32.WORD[6].W.B0.q_wire[7] SLICE[0].RAM8x32.WORD[6].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[7] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[6].W.B0.CG SLICE[0].RAM8x32.WORD[6].W.B0.CLK_B
+ SLICE[0].RAM8x32.WORD[6].W.B0.we_wire VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[6].W.B0.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[0].RAM8x32.WORD[6].W.B0.CGAND SLICE[0].RAM8x32.WORD[6].W.B0.SEL
+ SLICE[0].RAM8x32.WORD[0].W.B0.WE VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[6].W.B0.we_wire sky130_fd_sc_hd__and2_1
XSLICE[0].RAM8x32.WORD[6].W.B0.CLKINV SLICE[0].RAM8x32.WORD[6].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[6].W.B0.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[6].W.B0.SELINV SLICE[0].RAM8x32.WORD[6].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[6].W.B0.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[6].W.B1.BIT[0].LATCH SLICE[0].RAM8x32.Di[8]
+ SLICE[0].RAM8x32.WORD[6].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[6].W.B1.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[6].W.B1.BIT[0].OBUF
+ SLICE[0].RAM8x32.WORD[6].W.B1.q_wire[0] SLICE[0].RAM8x32.WORD[6].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[8] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[6].W.B1.BIT[1].LATCH SLICE[0].RAM8x32.Di[9]
+ SLICE[0].RAM8x32.WORD[6].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[6].W.B1.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[6].W.B1.BIT[1].OBUF
+ SLICE[0].RAM8x32.WORD[6].W.B1.q_wire[1] SLICE[0].RAM8x32.WORD[6].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[9] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[6].W.B1.BIT[2].LATCH SLICE[0].RAM8x32.Di[10]
+ SLICE[0].RAM8x32.WORD[6].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[6].W.B1.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[6].W.B1.BIT[2].OBUF
+ SLICE[0].RAM8x32.WORD[6].W.B1.q_wire[2] SLICE[0].RAM8x32.WORD[6].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[10] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[6].W.B1.BIT[3].LATCH SLICE[0].RAM8x32.Di[11]
+ SLICE[0].RAM8x32.WORD[6].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[6].W.B1.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[6].W.B1.BIT[3].OBUF
+ SLICE[0].RAM8x32.WORD[6].W.B1.q_wire[3] SLICE[0].RAM8x32.WORD[6].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[11] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[6].W.B1.BIT[4].LATCH SLICE[0].RAM8x32.Di[12]
+ SLICE[0].RAM8x32.WORD[6].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[6].W.B1.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[6].W.B1.BIT[4].OBUF
+ SLICE[0].RAM8x32.WORD[6].W.B1.q_wire[4] SLICE[0].RAM8x32.WORD[6].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[12] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[6].W.B1.BIT[5].LATCH SLICE[0].RAM8x32.Di[13]
+ SLICE[0].RAM8x32.WORD[6].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[6].W.B1.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[6].W.B1.BIT[5].OBUF
+ SLICE[0].RAM8x32.WORD[6].W.B1.q_wire[5] SLICE[0].RAM8x32.WORD[6].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[13] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[6].W.B1.BIT[6].LATCH SLICE[0].RAM8x32.Di[14]
+ SLICE[0].RAM8x32.WORD[6].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[6].W.B1.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[6].W.B1.BIT[6].OBUF
+ SLICE[0].RAM8x32.WORD[6].W.B1.q_wire[6] SLICE[0].RAM8x32.WORD[6].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[14] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[6].W.B1.BIT[7].LATCH SLICE[0].RAM8x32.Di[15]
+ SLICE[0].RAM8x32.WORD[6].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[6].W.B1.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[6].W.B1.BIT[7].OBUF
+ SLICE[0].RAM8x32.WORD[6].W.B1.q_wire[7] SLICE[0].RAM8x32.WORD[6].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[15] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[6].W.B1.CG SLICE[0].RAM8x32.WORD[6].W.B1.CLK_B
+ SLICE[0].RAM8x32.WORD[6].W.B1.we_wire VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[6].W.B1.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[0].RAM8x32.WORD[6].W.B1.CGAND SLICE[0].RAM8x32.WORD[6].W.B0.SEL
+ SLICE[0].RAM8x32.WORD[0].W.B1.WE VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[6].W.B1.we_wire sky130_fd_sc_hd__and2_1
XSLICE[0].RAM8x32.WORD[6].W.B1.CLKINV SLICE[0].RAM8x32.WORD[6].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[6].W.B1.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[6].W.B1.SELINV SLICE[0].RAM8x32.WORD[6].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[6].W.B1.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[6].W.B2.BIT[0].LATCH SLICE[0].RAM8x32.Di[16]
+ SLICE[0].RAM8x32.WORD[6].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[6].W.B2.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[6].W.B2.BIT[0].OBUF
+ SLICE[0].RAM8x32.WORD[6].W.B2.q_wire[0] SLICE[0].RAM8x32.WORD[6].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[16] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[6].W.B2.BIT[1].LATCH SLICE[0].RAM8x32.Di[17]
+ SLICE[0].RAM8x32.WORD[6].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[6].W.B2.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[6].W.B2.BIT[1].OBUF
+ SLICE[0].RAM8x32.WORD[6].W.B2.q_wire[1] SLICE[0].RAM8x32.WORD[6].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[17] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[6].W.B2.BIT[2].LATCH SLICE[0].RAM8x32.Di[18]
+ SLICE[0].RAM8x32.WORD[6].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[6].W.B2.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[6].W.B2.BIT[2].OBUF
+ SLICE[0].RAM8x32.WORD[6].W.B2.q_wire[2] SLICE[0].RAM8x32.WORD[6].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[18] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[6].W.B2.BIT[3].LATCH SLICE[0].RAM8x32.Di[19]
+ SLICE[0].RAM8x32.WORD[6].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[6].W.B2.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[6].W.B2.BIT[3].OBUF
+ SLICE[0].RAM8x32.WORD[6].W.B2.q_wire[3] SLICE[0].RAM8x32.WORD[6].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[19] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[6].W.B2.BIT[4].LATCH SLICE[0].RAM8x32.Di[20]
+ SLICE[0].RAM8x32.WORD[6].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[6].W.B2.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[6].W.B2.BIT[4].OBUF
+ SLICE[0].RAM8x32.WORD[6].W.B2.q_wire[4] SLICE[0].RAM8x32.WORD[6].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[20] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[6].W.B2.BIT[5].LATCH SLICE[0].RAM8x32.Di[21]
+ SLICE[0].RAM8x32.WORD[6].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[6].W.B2.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[6].W.B2.BIT[5].OBUF
+ SLICE[0].RAM8x32.WORD[6].W.B2.q_wire[5] SLICE[0].RAM8x32.WORD[6].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[21] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[6].W.B2.BIT[6].LATCH SLICE[0].RAM8x32.Di[22]
+ SLICE[0].RAM8x32.WORD[6].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[6].W.B2.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[6].W.B2.BIT[6].OBUF
+ SLICE[0].RAM8x32.WORD[6].W.B2.q_wire[6] SLICE[0].RAM8x32.WORD[6].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[22] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[6].W.B2.BIT[7].LATCH SLICE[0].RAM8x32.Di[23]
+ SLICE[0].RAM8x32.WORD[6].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[6].W.B2.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[6].W.B2.BIT[7].OBUF
+ SLICE[0].RAM8x32.WORD[6].W.B2.q_wire[7] SLICE[0].RAM8x32.WORD[6].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[23] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[6].W.B2.CG SLICE[0].RAM8x32.WORD[6].W.B2.CLK_B
+ SLICE[0].RAM8x32.WORD[6].W.B2.we_wire VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[6].W.B2.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[0].RAM8x32.WORD[6].W.B2.CGAND SLICE[0].RAM8x32.WORD[6].W.B0.SEL
+ SLICE[0].RAM8x32.WORD[0].W.B2.WE VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[6].W.B2.we_wire sky130_fd_sc_hd__and2_1
XSLICE[0].RAM8x32.WORD[6].W.B2.CLKINV SLICE[0].RAM8x32.WORD[6].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[6].W.B2.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[6].W.B2.SELINV SLICE[0].RAM8x32.WORD[6].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[6].W.B2.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[6].W.B3.BIT[0].LATCH SLICE[0].RAM8x32.Di[24]
+ SLICE[0].RAM8x32.WORD[6].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[6].W.B3.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[6].W.B3.BIT[0].OBUF
+ SLICE[0].RAM8x32.WORD[6].W.B3.q_wire[0] SLICE[0].RAM8x32.WORD[6].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[24] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[6].W.B3.BIT[1].LATCH SLICE[0].RAM8x32.Di[25]
+ SLICE[0].RAM8x32.WORD[6].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[6].W.B3.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[6].W.B3.BIT[1].OBUF
+ SLICE[0].RAM8x32.WORD[6].W.B3.q_wire[1] SLICE[0].RAM8x32.WORD[6].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[25] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[6].W.B3.BIT[2].LATCH SLICE[0].RAM8x32.Di[26]
+ SLICE[0].RAM8x32.WORD[6].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[6].W.B3.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[6].W.B3.BIT[2].OBUF
+ SLICE[0].RAM8x32.WORD[6].W.B3.q_wire[2] SLICE[0].RAM8x32.WORD[6].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[26] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[6].W.B3.BIT[3].LATCH SLICE[0].RAM8x32.Di[27]
+ SLICE[0].RAM8x32.WORD[6].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[6].W.B3.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[6].W.B3.BIT[3].OBUF
+ SLICE[0].RAM8x32.WORD[6].W.B3.q_wire[3] SLICE[0].RAM8x32.WORD[6].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[27] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[6].W.B3.BIT[4].LATCH SLICE[0].RAM8x32.Di[28]
+ SLICE[0].RAM8x32.WORD[6].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[6].W.B3.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[6].W.B3.BIT[4].OBUF
+ SLICE[0].RAM8x32.WORD[6].W.B3.q_wire[4] SLICE[0].RAM8x32.WORD[6].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[28] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[6].W.B3.BIT[5].LATCH SLICE[0].RAM8x32.Di[29]
+ SLICE[0].RAM8x32.WORD[6].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[6].W.B3.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[6].W.B3.BIT[5].OBUF
+ SLICE[0].RAM8x32.WORD[6].W.B3.q_wire[5] SLICE[0].RAM8x32.WORD[6].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[29] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[6].W.B3.BIT[6].LATCH SLICE[0].RAM8x32.Di[30]
+ SLICE[0].RAM8x32.WORD[6].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[6].W.B3.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[6].W.B3.BIT[6].OBUF
+ SLICE[0].RAM8x32.WORD[6].W.B3.q_wire[6] SLICE[0].RAM8x32.WORD[6].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[30] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[6].W.B3.BIT[7].LATCH SLICE[0].RAM8x32.Di[31]
+ SLICE[0].RAM8x32.WORD[6].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[6].W.B3.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[6].W.B3.BIT[7].OBUF
+ SLICE[0].RAM8x32.WORD[6].W.B3.q_wire[7] SLICE[0].RAM8x32.WORD[6].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[31] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[6].W.B3.CG SLICE[0].RAM8x32.WORD[6].W.B3.CLK_B
+ SLICE[0].RAM8x32.WORD[6].W.B3.we_wire VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[6].W.B3.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[0].RAM8x32.WORD[6].W.B3.CGAND SLICE[0].RAM8x32.WORD[6].W.B0.SEL
+ SLICE[0].RAM8x32.WORD[0].W.B3.WE VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[6].W.B3.we_wire sky130_fd_sc_hd__and2_1
XSLICE[0].RAM8x32.WORD[6].W.B3.CLKINV SLICE[0].RAM8x32.WORD[6].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[6].W.B3.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[6].W.B3.SELINV SLICE[0].RAM8x32.WORD[6].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[6].W.B3.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[6].W.CLKBUF SLICE[0].RAM8x32.CLK_buf VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[6].W.B0.CLK sky130_fd_sc_hd__clkbuf_1
XSLICE[0].RAM8x32.WORD[6].W.SELBUF SLICE[0].RAM8x32.WORD[6].W.SEL VGND VGND
+ VPWR VPWR SLICE[0].RAM8x32.WORD[6].W.B0.SEL sky130_fd_sc_hd__clkbuf_2
XSLICE[0].RAM8x32.WORD[7].W.B0.BIT[0].LATCH SLICE[0].RAM8x32.Di[0]
+ SLICE[0].RAM8x32.WORD[7].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[7].W.B0.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[7].W.B0.BIT[0].OBUF
+ SLICE[0].RAM8x32.WORD[7].W.B0.q_wire[0] SLICE[0].RAM8x32.WORD[7].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[0] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[7].W.B0.BIT[1].LATCH SLICE[0].RAM8x32.Di[1]
+ SLICE[0].RAM8x32.WORD[7].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[7].W.B0.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[7].W.B0.BIT[1].OBUF
+ SLICE[0].RAM8x32.WORD[7].W.B0.q_wire[1] SLICE[0].RAM8x32.WORD[7].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[1] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[7].W.B0.BIT[2].LATCH SLICE[0].RAM8x32.Di[2]
+ SLICE[0].RAM8x32.WORD[7].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[7].W.B0.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[7].W.B0.BIT[2].OBUF
+ SLICE[0].RAM8x32.WORD[7].W.B0.q_wire[2] SLICE[0].RAM8x32.WORD[7].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[2] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[7].W.B0.BIT[3].LATCH SLICE[0].RAM8x32.Di[3]
+ SLICE[0].RAM8x32.WORD[7].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[7].W.B0.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[7].W.B0.BIT[3].OBUF
+ SLICE[0].RAM8x32.WORD[7].W.B0.q_wire[3] SLICE[0].RAM8x32.WORD[7].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[3] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[7].W.B0.BIT[4].LATCH SLICE[0].RAM8x32.Di[4]
+ SLICE[0].RAM8x32.WORD[7].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[7].W.B0.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[7].W.B0.BIT[4].OBUF
+ SLICE[0].RAM8x32.WORD[7].W.B0.q_wire[4] SLICE[0].RAM8x32.WORD[7].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[4] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[7].W.B0.BIT[5].LATCH SLICE[0].RAM8x32.Di[5]
+ SLICE[0].RAM8x32.WORD[7].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[7].W.B0.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[7].W.B0.BIT[5].OBUF
+ SLICE[0].RAM8x32.WORD[7].W.B0.q_wire[5] SLICE[0].RAM8x32.WORD[7].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[5] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[7].W.B0.BIT[6].LATCH SLICE[0].RAM8x32.Di[6]
+ SLICE[0].RAM8x32.WORD[7].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[7].W.B0.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[7].W.B0.BIT[6].OBUF
+ SLICE[0].RAM8x32.WORD[7].W.B0.q_wire[6] SLICE[0].RAM8x32.WORD[7].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[6] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[7].W.B0.BIT[7].LATCH SLICE[0].RAM8x32.Di[7]
+ SLICE[0].RAM8x32.WORD[7].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[7].W.B0.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[7].W.B0.BIT[7].OBUF
+ SLICE[0].RAM8x32.WORD[7].W.B0.q_wire[7] SLICE[0].RAM8x32.WORD[7].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[7] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[7].W.B0.CG SLICE[0].RAM8x32.WORD[7].W.B0.CLK_B
+ SLICE[0].RAM8x32.WORD[7].W.B0.we_wire VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[7].W.B0.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[0].RAM8x32.WORD[7].W.B0.CGAND SLICE[0].RAM8x32.WORD[7].W.B0.SEL
+ SLICE[0].RAM8x32.WORD[0].W.B0.WE VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[7].W.B0.we_wire sky130_fd_sc_hd__and2_1
XSLICE[0].RAM8x32.WORD[7].W.B0.CLKINV SLICE[0].RAM8x32.WORD[7].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[7].W.B0.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[7].W.B0.SELINV SLICE[0].RAM8x32.WORD[7].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[7].W.B0.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[7].W.B1.BIT[0].LATCH SLICE[0].RAM8x32.Di[8]
+ SLICE[0].RAM8x32.WORD[7].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[7].W.B1.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[7].W.B1.BIT[0].OBUF
+ SLICE[0].RAM8x32.WORD[7].W.B1.q_wire[0] SLICE[0].RAM8x32.WORD[7].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[8] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[7].W.B1.BIT[1].LATCH SLICE[0].RAM8x32.Di[9]
+ SLICE[0].RAM8x32.WORD[7].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[7].W.B1.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[7].W.B1.BIT[1].OBUF
+ SLICE[0].RAM8x32.WORD[7].W.B1.q_wire[1] SLICE[0].RAM8x32.WORD[7].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[9] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[7].W.B1.BIT[2].LATCH SLICE[0].RAM8x32.Di[10]
+ SLICE[0].RAM8x32.WORD[7].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[7].W.B1.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[7].W.B1.BIT[2].OBUF
+ SLICE[0].RAM8x32.WORD[7].W.B1.q_wire[2] SLICE[0].RAM8x32.WORD[7].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[10] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[7].W.B1.BIT[3].LATCH SLICE[0].RAM8x32.Di[11]
+ SLICE[0].RAM8x32.WORD[7].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[7].W.B1.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[7].W.B1.BIT[3].OBUF
+ SLICE[0].RAM8x32.WORD[7].W.B1.q_wire[3] SLICE[0].RAM8x32.WORD[7].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[11] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[7].W.B1.BIT[4].LATCH SLICE[0].RAM8x32.Di[12]
+ SLICE[0].RAM8x32.WORD[7].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[7].W.B1.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[7].W.B1.BIT[4].OBUF
+ SLICE[0].RAM8x32.WORD[7].W.B1.q_wire[4] SLICE[0].RAM8x32.WORD[7].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[12] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[7].W.B1.BIT[5].LATCH SLICE[0].RAM8x32.Di[13]
+ SLICE[0].RAM8x32.WORD[7].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[7].W.B1.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[7].W.B1.BIT[5].OBUF
+ SLICE[0].RAM8x32.WORD[7].W.B1.q_wire[5] SLICE[0].RAM8x32.WORD[7].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[13] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[7].W.B1.BIT[6].LATCH SLICE[0].RAM8x32.Di[14]
+ SLICE[0].RAM8x32.WORD[7].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[7].W.B1.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[7].W.B1.BIT[6].OBUF
+ SLICE[0].RAM8x32.WORD[7].W.B1.q_wire[6] SLICE[0].RAM8x32.WORD[7].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[14] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[7].W.B1.BIT[7].LATCH SLICE[0].RAM8x32.Di[15]
+ SLICE[0].RAM8x32.WORD[7].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[7].W.B1.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[7].W.B1.BIT[7].OBUF
+ SLICE[0].RAM8x32.WORD[7].W.B1.q_wire[7] SLICE[0].RAM8x32.WORD[7].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[15] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[7].W.B1.CG SLICE[0].RAM8x32.WORD[7].W.B1.CLK_B
+ SLICE[0].RAM8x32.WORD[7].W.B1.we_wire VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[7].W.B1.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[0].RAM8x32.WORD[7].W.B1.CGAND SLICE[0].RAM8x32.WORD[7].W.B0.SEL
+ SLICE[0].RAM8x32.WORD[0].W.B1.WE VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[7].W.B1.we_wire sky130_fd_sc_hd__and2_1
XSLICE[0].RAM8x32.WORD[7].W.B1.CLKINV SLICE[0].RAM8x32.WORD[7].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[7].W.B1.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[7].W.B1.SELINV SLICE[0].RAM8x32.WORD[7].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[7].W.B1.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[7].W.B2.BIT[0].LATCH SLICE[0].RAM8x32.Di[16]
+ SLICE[0].RAM8x32.WORD[7].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[7].W.B2.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[7].W.B2.BIT[0].OBUF
+ SLICE[0].RAM8x32.WORD[7].W.B2.q_wire[0] SLICE[0].RAM8x32.WORD[7].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[16] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[7].W.B2.BIT[1].LATCH SLICE[0].RAM8x32.Di[17]
+ SLICE[0].RAM8x32.WORD[7].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[7].W.B2.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[7].W.B2.BIT[1].OBUF
+ SLICE[0].RAM8x32.WORD[7].W.B2.q_wire[1] SLICE[0].RAM8x32.WORD[7].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[17] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[7].W.B2.BIT[2].LATCH SLICE[0].RAM8x32.Di[18]
+ SLICE[0].RAM8x32.WORD[7].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[7].W.B2.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[7].W.B2.BIT[2].OBUF
+ SLICE[0].RAM8x32.WORD[7].W.B2.q_wire[2] SLICE[0].RAM8x32.WORD[7].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[18] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[7].W.B2.BIT[3].LATCH SLICE[0].RAM8x32.Di[19]
+ SLICE[0].RAM8x32.WORD[7].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[7].W.B2.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[7].W.B2.BIT[3].OBUF
+ SLICE[0].RAM8x32.WORD[7].W.B2.q_wire[3] SLICE[0].RAM8x32.WORD[7].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[19] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[7].W.B2.BIT[4].LATCH SLICE[0].RAM8x32.Di[20]
+ SLICE[0].RAM8x32.WORD[7].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[7].W.B2.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[7].W.B2.BIT[4].OBUF
+ SLICE[0].RAM8x32.WORD[7].W.B2.q_wire[4] SLICE[0].RAM8x32.WORD[7].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[20] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[7].W.B2.BIT[5].LATCH SLICE[0].RAM8x32.Di[21]
+ SLICE[0].RAM8x32.WORD[7].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[7].W.B2.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[7].W.B2.BIT[5].OBUF
+ SLICE[0].RAM8x32.WORD[7].W.B2.q_wire[5] SLICE[0].RAM8x32.WORD[7].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[21] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[7].W.B2.BIT[6].LATCH SLICE[0].RAM8x32.Di[22]
+ SLICE[0].RAM8x32.WORD[7].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[7].W.B2.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[7].W.B2.BIT[6].OBUF
+ SLICE[0].RAM8x32.WORD[7].W.B2.q_wire[6] SLICE[0].RAM8x32.WORD[7].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[22] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[7].W.B2.BIT[7].LATCH SLICE[0].RAM8x32.Di[23]
+ SLICE[0].RAM8x32.WORD[7].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[7].W.B2.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[7].W.B2.BIT[7].OBUF
+ SLICE[0].RAM8x32.WORD[7].W.B2.q_wire[7] SLICE[0].RAM8x32.WORD[7].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[23] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[7].W.B2.CG SLICE[0].RAM8x32.WORD[7].W.B2.CLK_B
+ SLICE[0].RAM8x32.WORD[7].W.B2.we_wire VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[7].W.B2.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[0].RAM8x32.WORD[7].W.B2.CGAND SLICE[0].RAM8x32.WORD[7].W.B0.SEL
+ SLICE[0].RAM8x32.WORD[0].W.B2.WE VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[7].W.B2.we_wire sky130_fd_sc_hd__and2_1
XSLICE[0].RAM8x32.WORD[7].W.B2.CLKINV SLICE[0].RAM8x32.WORD[7].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[7].W.B2.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[7].W.B2.SELINV SLICE[0].RAM8x32.WORD[7].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[7].W.B2.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[7].W.B3.BIT[0].LATCH SLICE[0].RAM8x32.Di[24]
+ SLICE[0].RAM8x32.WORD[7].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[7].W.B3.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[7].W.B3.BIT[0].OBUF
+ SLICE[0].RAM8x32.WORD[7].W.B3.q_wire[0] SLICE[0].RAM8x32.WORD[7].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[24] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[7].W.B3.BIT[1].LATCH SLICE[0].RAM8x32.Di[25]
+ SLICE[0].RAM8x32.WORD[7].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[7].W.B3.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[7].W.B3.BIT[1].OBUF
+ SLICE[0].RAM8x32.WORD[7].W.B3.q_wire[1] SLICE[0].RAM8x32.WORD[7].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[25] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[7].W.B3.BIT[2].LATCH SLICE[0].RAM8x32.Di[26]
+ SLICE[0].RAM8x32.WORD[7].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[7].W.B3.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[7].W.B3.BIT[2].OBUF
+ SLICE[0].RAM8x32.WORD[7].W.B3.q_wire[2] SLICE[0].RAM8x32.WORD[7].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[26] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[7].W.B3.BIT[3].LATCH SLICE[0].RAM8x32.Di[27]
+ SLICE[0].RAM8x32.WORD[7].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[7].W.B3.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[7].W.B3.BIT[3].OBUF
+ SLICE[0].RAM8x32.WORD[7].W.B3.q_wire[3] SLICE[0].RAM8x32.WORD[7].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[27] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[7].W.B3.BIT[4].LATCH SLICE[0].RAM8x32.Di[28]
+ SLICE[0].RAM8x32.WORD[7].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[7].W.B3.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[7].W.B3.BIT[4].OBUF
+ SLICE[0].RAM8x32.WORD[7].W.B3.q_wire[4] SLICE[0].RAM8x32.WORD[7].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[28] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[7].W.B3.BIT[5].LATCH SLICE[0].RAM8x32.Di[29]
+ SLICE[0].RAM8x32.WORD[7].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[7].W.B3.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[7].W.B3.BIT[5].OBUF
+ SLICE[0].RAM8x32.WORD[7].W.B3.q_wire[5] SLICE[0].RAM8x32.WORD[7].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[29] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[7].W.B3.BIT[6].LATCH SLICE[0].RAM8x32.Di[30]
+ SLICE[0].RAM8x32.WORD[7].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[7].W.B3.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[7].W.B3.BIT[6].OBUF
+ SLICE[0].RAM8x32.WORD[7].W.B3.q_wire[6] SLICE[0].RAM8x32.WORD[7].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[30] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[7].W.B3.BIT[7].LATCH SLICE[0].RAM8x32.Di[31]
+ SLICE[0].RAM8x32.WORD[7].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[7].W.B3.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[0].RAM8x32.WORD[7].W.B3.BIT[7].OBUF
+ SLICE[0].RAM8x32.WORD[7].W.B3.q_wire[7] SLICE[0].RAM8x32.WORD[7].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[31] sky130_fd_sc_hd__ebufn_2
XSLICE[0].RAM8x32.WORD[7].W.B3.CG SLICE[0].RAM8x32.WORD[7].W.B3.CLK_B
+ SLICE[0].RAM8x32.WORD[7].W.B3.we_wire VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[7].W.B3.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[0].RAM8x32.WORD[7].W.B3.CGAND SLICE[0].RAM8x32.WORD[7].W.B0.SEL
+ SLICE[0].RAM8x32.WORD[0].W.B3.WE VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[7].W.B3.we_wire sky130_fd_sc_hd__and2_1
XSLICE[0].RAM8x32.WORD[7].W.B3.CLKINV SLICE[0].RAM8x32.WORD[7].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[7].W.B3.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[7].W.B3.SELINV SLICE[0].RAM8x32.WORD[7].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[0].RAM8x32.WORD[7].W.B3.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[0].RAM8x32.WORD[7].W.CLKBUF SLICE[0].RAM8x32.CLK_buf VGND VGND VPWR VPWR
+ SLICE[0].RAM8x32.WORD[7].W.B0.CLK sky130_fd_sc_hd__clkbuf_1
XSLICE[0].RAM8x32.WORD[7].W.SELBUF SLICE[0].RAM8x32.WORD[7].W.SEL VGND VGND
+ VPWR VPWR SLICE[0].RAM8x32.WORD[7].W.B0.SEL sky130_fd_sc_hd__clkbuf_2
XSLICE[1].RAM8x32.CLKBUF SLICE[0].RAM8x32.CLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.CLK_buf sky130_fd_sc_hd__clkbuf_2
XSLICE[1].RAM8x32.DEC.ABUF[0] SLICE[0].RAM8x32.A[0] VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.DEC.A_buf[0] sky130_fd_sc_hd__clkbuf_2
XSLICE[1].RAM8x32.DEC.ABUF[1] SLICE[0].RAM8x32.A[1] VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.DEC.A_buf[1] sky130_fd_sc_hd__clkbuf_2
XSLICE[1].RAM8x32.DEC.ABUF[2] SLICE[0].RAM8x32.A[2] VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.DEC.A_buf[2] sky130_fd_sc_hd__clkbuf_2
XSLICE[1].RAM8x32.DEC.AND0 SLICE[1].RAM8x32.DEC.A_buf[0]
+ SLICE[1].RAM8x32.DEC.A_buf[1] SLICE[1].RAM8x32.DEC.A_buf[2]
+ SLICE[1].RAM8x32.DEC.EN_buf VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[0].W.SEL sky130_fd_sc_hd__nor4b_2
XSLICE[1].RAM8x32.DEC.AND1 SLICE[1].RAM8x32.DEC.A_buf[2]
+ SLICE[1].RAM8x32.DEC.A_buf[1] SLICE[1].RAM8x32.DEC.A_buf[0]
+ SLICE[1].RAM8x32.DEC.EN_buf VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[1].W.SEL sky130_fd_sc_hd__and4bb_2
XSLICE[1].RAM8x32.DEC.AND2 SLICE[1].RAM8x32.DEC.A_buf[2]
+ SLICE[1].RAM8x32.DEC.A_buf[0] SLICE[1].RAM8x32.DEC.A_buf[1]
+ SLICE[1].RAM8x32.DEC.EN_buf VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[2].W.SEL sky130_fd_sc_hd__and4bb_2
XSLICE[1].RAM8x32.DEC.AND3 SLICE[1].RAM8x32.DEC.A_buf[2]
+ SLICE[1].RAM8x32.DEC.A_buf[1] SLICE[1].RAM8x32.DEC.A_buf[0]
+ SLICE[1].RAM8x32.DEC.EN_buf VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[3].W.SEL sky130_fd_sc_hd__and4b_2
XSLICE[1].RAM8x32.DEC.AND4 SLICE[1].RAM8x32.DEC.A_buf[0]
+ SLICE[1].RAM8x32.DEC.A_buf[1] SLICE[1].RAM8x32.DEC.A_buf[2]
+ SLICE[1].RAM8x32.DEC.EN_buf VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[4].W.SEL sky130_fd_sc_hd__and4bb_2
XSLICE[1].RAM8x32.DEC.AND5 SLICE[1].RAM8x32.DEC.A_buf[1]
+ SLICE[1].RAM8x32.DEC.A_buf[0] SLICE[1].RAM8x32.DEC.A_buf[2]
+ SLICE[1].RAM8x32.DEC.EN_buf VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[5].W.SEL sky130_fd_sc_hd__and4b_2
XSLICE[1].RAM8x32.DEC.AND6 SLICE[1].RAM8x32.DEC.A_buf[0]
+ SLICE[1].RAM8x32.DEC.A_buf[1] SLICE[1].RAM8x32.DEC.A_buf[2]
+ SLICE[1].RAM8x32.DEC.EN_buf VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[6].W.SEL sky130_fd_sc_hd__and4b_2
XSLICE[1].RAM8x32.DEC.AND7 SLICE[1].RAM8x32.DEC.A_buf[0]
+ SLICE[1].RAM8x32.DEC.A_buf[1] SLICE[1].RAM8x32.DEC.A_buf[2]
+ SLICE[1].RAM8x32.DEC.EN_buf VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[7].W.SEL sky130_fd_sc_hd__and4_2
XSLICE[1].RAM8x32.DEC.ENBUF SLICE[1].RAM8x32.DEC.EN VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.DEC.EN_buf sky130_fd_sc_hd__clkbuf_2
XSLICE[1].RAM8x32.WEBUF[0] SLICE[0].RAM8x32.WE[0] VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[0].W.B0.WE sky130_fd_sc_hd__clkbuf_2
XSLICE[1].RAM8x32.WEBUF[1] SLICE[0].RAM8x32.WE[1] VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[0].W.B1.WE sky130_fd_sc_hd__clkbuf_2
XSLICE[1].RAM8x32.WEBUF[2] SLICE[0].RAM8x32.WE[2] VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[0].W.B2.WE sky130_fd_sc_hd__clkbuf_2
XSLICE[1].RAM8x32.WEBUF[3] SLICE[0].RAM8x32.WE[3] VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[0].W.B3.WE sky130_fd_sc_hd__clkbuf_2
XSLICE[1].RAM8x32.WORD[0].W.B0.BIT[0].LATCH SLICE[0].RAM8x32.Di[0]
+ SLICE[1].RAM8x32.WORD[0].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[0].W.B0.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[0].W.B0.BIT[0].OBUF
+ SLICE[1].RAM8x32.WORD[0].W.B0.q_wire[0] SLICE[1].RAM8x32.WORD[0].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[0] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[0].W.B0.BIT[1].LATCH SLICE[0].RAM8x32.Di[1]
+ SLICE[1].RAM8x32.WORD[0].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[0].W.B0.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[0].W.B0.BIT[1].OBUF
+ SLICE[1].RAM8x32.WORD[0].W.B0.q_wire[1] SLICE[1].RAM8x32.WORD[0].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[1] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[0].W.B0.BIT[2].LATCH SLICE[0].RAM8x32.Di[2]
+ SLICE[1].RAM8x32.WORD[0].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[0].W.B0.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[0].W.B0.BIT[2].OBUF
+ SLICE[1].RAM8x32.WORD[0].W.B0.q_wire[2] SLICE[1].RAM8x32.WORD[0].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[2] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[0].W.B0.BIT[3].LATCH SLICE[0].RAM8x32.Di[3]
+ SLICE[1].RAM8x32.WORD[0].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[0].W.B0.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[0].W.B0.BIT[3].OBUF
+ SLICE[1].RAM8x32.WORD[0].W.B0.q_wire[3] SLICE[1].RAM8x32.WORD[0].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[3] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[0].W.B0.BIT[4].LATCH SLICE[0].RAM8x32.Di[4]
+ SLICE[1].RAM8x32.WORD[0].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[0].W.B0.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[0].W.B0.BIT[4].OBUF
+ SLICE[1].RAM8x32.WORD[0].W.B0.q_wire[4] SLICE[1].RAM8x32.WORD[0].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[4] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[0].W.B0.BIT[5].LATCH SLICE[0].RAM8x32.Di[5]
+ SLICE[1].RAM8x32.WORD[0].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[0].W.B0.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[0].W.B0.BIT[5].OBUF
+ SLICE[1].RAM8x32.WORD[0].W.B0.q_wire[5] SLICE[1].RAM8x32.WORD[0].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[5] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[0].W.B0.BIT[6].LATCH SLICE[0].RAM8x32.Di[6]
+ SLICE[1].RAM8x32.WORD[0].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[0].W.B0.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[0].W.B0.BIT[6].OBUF
+ SLICE[1].RAM8x32.WORD[0].W.B0.q_wire[6] SLICE[1].RAM8x32.WORD[0].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[6] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[0].W.B0.BIT[7].LATCH SLICE[0].RAM8x32.Di[7]
+ SLICE[1].RAM8x32.WORD[0].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[0].W.B0.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[0].W.B0.BIT[7].OBUF
+ SLICE[1].RAM8x32.WORD[0].W.B0.q_wire[7] SLICE[1].RAM8x32.WORD[0].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[7] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[0].W.B0.CG SLICE[1].RAM8x32.WORD[0].W.B0.CLK_B
+ SLICE[1].RAM8x32.WORD[0].W.B0.we_wire VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[0].W.B0.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[1].RAM8x32.WORD[0].W.B0.CGAND SLICE[1].RAM8x32.WORD[0].W.B0.SEL
+ SLICE[1].RAM8x32.WORD[0].W.B0.WE VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[0].W.B0.we_wire sky130_fd_sc_hd__and2_1
XSLICE[1].RAM8x32.WORD[0].W.B0.CLKINV SLICE[1].RAM8x32.WORD[0].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[0].W.B0.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[0].W.B0.SELINV SLICE[1].RAM8x32.WORD[0].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[0].W.B0.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[0].W.B1.BIT[0].LATCH SLICE[0].RAM8x32.Di[8]
+ SLICE[1].RAM8x32.WORD[0].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[0].W.B1.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[0].W.B1.BIT[0].OBUF
+ SLICE[1].RAM8x32.WORD[0].W.B1.q_wire[0] SLICE[1].RAM8x32.WORD[0].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[8] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[0].W.B1.BIT[1].LATCH SLICE[0].RAM8x32.Di[9]
+ SLICE[1].RAM8x32.WORD[0].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[0].W.B1.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[0].W.B1.BIT[1].OBUF
+ SLICE[1].RAM8x32.WORD[0].W.B1.q_wire[1] SLICE[1].RAM8x32.WORD[0].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[9] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[0].W.B1.BIT[2].LATCH SLICE[0].RAM8x32.Di[10]
+ SLICE[1].RAM8x32.WORD[0].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[0].W.B1.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[0].W.B1.BIT[2].OBUF
+ SLICE[1].RAM8x32.WORD[0].W.B1.q_wire[2] SLICE[1].RAM8x32.WORD[0].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[10] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[0].W.B1.BIT[3].LATCH SLICE[0].RAM8x32.Di[11]
+ SLICE[1].RAM8x32.WORD[0].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[0].W.B1.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[0].W.B1.BIT[3].OBUF
+ SLICE[1].RAM8x32.WORD[0].W.B1.q_wire[3] SLICE[1].RAM8x32.WORD[0].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[11] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[0].W.B1.BIT[4].LATCH SLICE[0].RAM8x32.Di[12]
+ SLICE[1].RAM8x32.WORD[0].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[0].W.B1.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[0].W.B1.BIT[4].OBUF
+ SLICE[1].RAM8x32.WORD[0].W.B1.q_wire[4] SLICE[1].RAM8x32.WORD[0].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[12] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[0].W.B1.BIT[5].LATCH SLICE[0].RAM8x32.Di[13]
+ SLICE[1].RAM8x32.WORD[0].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[0].W.B1.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[0].W.B1.BIT[5].OBUF
+ SLICE[1].RAM8x32.WORD[0].W.B1.q_wire[5] SLICE[1].RAM8x32.WORD[0].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[13] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[0].W.B1.BIT[6].LATCH SLICE[0].RAM8x32.Di[14]
+ SLICE[1].RAM8x32.WORD[0].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[0].W.B1.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[0].W.B1.BIT[6].OBUF
+ SLICE[1].RAM8x32.WORD[0].W.B1.q_wire[6] SLICE[1].RAM8x32.WORD[0].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[14] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[0].W.B1.BIT[7].LATCH SLICE[0].RAM8x32.Di[15]
+ SLICE[1].RAM8x32.WORD[0].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[0].W.B1.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[0].W.B1.BIT[7].OBUF
+ SLICE[1].RAM8x32.WORD[0].W.B1.q_wire[7] SLICE[1].RAM8x32.WORD[0].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[15] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[0].W.B1.CG SLICE[1].RAM8x32.WORD[0].W.B1.CLK_B
+ SLICE[1].RAM8x32.WORD[0].W.B1.we_wire VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[0].W.B1.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[1].RAM8x32.WORD[0].W.B1.CGAND SLICE[1].RAM8x32.WORD[0].W.B0.SEL
+ SLICE[1].RAM8x32.WORD[0].W.B1.WE VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[0].W.B1.we_wire sky130_fd_sc_hd__and2_1
XSLICE[1].RAM8x32.WORD[0].W.B1.CLKINV SLICE[1].RAM8x32.WORD[0].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[0].W.B1.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[0].W.B1.SELINV SLICE[1].RAM8x32.WORD[0].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[0].W.B1.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[0].W.B2.BIT[0].LATCH SLICE[0].RAM8x32.Di[16]
+ SLICE[1].RAM8x32.WORD[0].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[0].W.B2.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[0].W.B2.BIT[0].OBUF
+ SLICE[1].RAM8x32.WORD[0].W.B2.q_wire[0] SLICE[1].RAM8x32.WORD[0].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[16] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[0].W.B2.BIT[1].LATCH SLICE[0].RAM8x32.Di[17]
+ SLICE[1].RAM8x32.WORD[0].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[0].W.B2.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[0].W.B2.BIT[1].OBUF
+ SLICE[1].RAM8x32.WORD[0].W.B2.q_wire[1] SLICE[1].RAM8x32.WORD[0].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[17] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[0].W.B2.BIT[2].LATCH SLICE[0].RAM8x32.Di[18]
+ SLICE[1].RAM8x32.WORD[0].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[0].W.B2.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[0].W.B2.BIT[2].OBUF
+ SLICE[1].RAM8x32.WORD[0].W.B2.q_wire[2] SLICE[1].RAM8x32.WORD[0].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[18] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[0].W.B2.BIT[3].LATCH SLICE[0].RAM8x32.Di[19]
+ SLICE[1].RAM8x32.WORD[0].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[0].W.B2.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[0].W.B2.BIT[3].OBUF
+ SLICE[1].RAM8x32.WORD[0].W.B2.q_wire[3] SLICE[1].RAM8x32.WORD[0].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[19] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[0].W.B2.BIT[4].LATCH SLICE[0].RAM8x32.Di[20]
+ SLICE[1].RAM8x32.WORD[0].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[0].W.B2.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[0].W.B2.BIT[4].OBUF
+ SLICE[1].RAM8x32.WORD[0].W.B2.q_wire[4] SLICE[1].RAM8x32.WORD[0].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[20] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[0].W.B2.BIT[5].LATCH SLICE[0].RAM8x32.Di[21]
+ SLICE[1].RAM8x32.WORD[0].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[0].W.B2.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[0].W.B2.BIT[5].OBUF
+ SLICE[1].RAM8x32.WORD[0].W.B2.q_wire[5] SLICE[1].RAM8x32.WORD[0].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[21] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[0].W.B2.BIT[6].LATCH SLICE[0].RAM8x32.Di[22]
+ SLICE[1].RAM8x32.WORD[0].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[0].W.B2.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[0].W.B2.BIT[6].OBUF
+ SLICE[1].RAM8x32.WORD[0].W.B2.q_wire[6] SLICE[1].RAM8x32.WORD[0].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[22] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[0].W.B2.BIT[7].LATCH SLICE[0].RAM8x32.Di[23]
+ SLICE[1].RAM8x32.WORD[0].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[0].W.B2.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[0].W.B2.BIT[7].OBUF
+ SLICE[1].RAM8x32.WORD[0].W.B2.q_wire[7] SLICE[1].RAM8x32.WORD[0].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[23] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[0].W.B2.CG SLICE[1].RAM8x32.WORD[0].W.B2.CLK_B
+ SLICE[1].RAM8x32.WORD[0].W.B2.we_wire VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[0].W.B2.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[1].RAM8x32.WORD[0].W.B2.CGAND SLICE[1].RAM8x32.WORD[0].W.B0.SEL
+ SLICE[1].RAM8x32.WORD[0].W.B2.WE VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[0].W.B2.we_wire sky130_fd_sc_hd__and2_1
XSLICE[1].RAM8x32.WORD[0].W.B2.CLKINV SLICE[1].RAM8x32.WORD[0].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[0].W.B2.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[0].W.B2.SELINV SLICE[1].RAM8x32.WORD[0].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[0].W.B2.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[0].W.B3.BIT[0].LATCH SLICE[0].RAM8x32.Di[24]
+ SLICE[1].RAM8x32.WORD[0].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[0].W.B3.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[0].W.B3.BIT[0].OBUF
+ SLICE[1].RAM8x32.WORD[0].W.B3.q_wire[0] SLICE[1].RAM8x32.WORD[0].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[24] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[0].W.B3.BIT[1].LATCH SLICE[0].RAM8x32.Di[25]
+ SLICE[1].RAM8x32.WORD[0].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[0].W.B3.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[0].W.B3.BIT[1].OBUF
+ SLICE[1].RAM8x32.WORD[0].W.B3.q_wire[1] SLICE[1].RAM8x32.WORD[0].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[25] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[0].W.B3.BIT[2].LATCH SLICE[0].RAM8x32.Di[26]
+ SLICE[1].RAM8x32.WORD[0].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[0].W.B3.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[0].W.B3.BIT[2].OBUF
+ SLICE[1].RAM8x32.WORD[0].W.B3.q_wire[2] SLICE[1].RAM8x32.WORD[0].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[26] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[0].W.B3.BIT[3].LATCH SLICE[0].RAM8x32.Di[27]
+ SLICE[1].RAM8x32.WORD[0].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[0].W.B3.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[0].W.B3.BIT[3].OBUF
+ SLICE[1].RAM8x32.WORD[0].W.B3.q_wire[3] SLICE[1].RAM8x32.WORD[0].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[27] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[0].W.B3.BIT[4].LATCH SLICE[0].RAM8x32.Di[28]
+ SLICE[1].RAM8x32.WORD[0].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[0].W.B3.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[0].W.B3.BIT[4].OBUF
+ SLICE[1].RAM8x32.WORD[0].W.B3.q_wire[4] SLICE[1].RAM8x32.WORD[0].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[28] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[0].W.B3.BIT[5].LATCH SLICE[0].RAM8x32.Di[29]
+ SLICE[1].RAM8x32.WORD[0].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[0].W.B3.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[0].W.B3.BIT[5].OBUF
+ SLICE[1].RAM8x32.WORD[0].W.B3.q_wire[5] SLICE[1].RAM8x32.WORD[0].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[29] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[0].W.B3.BIT[6].LATCH SLICE[0].RAM8x32.Di[30]
+ SLICE[1].RAM8x32.WORD[0].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[0].W.B3.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[0].W.B3.BIT[6].OBUF
+ SLICE[1].RAM8x32.WORD[0].W.B3.q_wire[6] SLICE[1].RAM8x32.WORD[0].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[30] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[0].W.B3.BIT[7].LATCH SLICE[0].RAM8x32.Di[31]
+ SLICE[1].RAM8x32.WORD[0].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[0].W.B3.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[0].W.B3.BIT[7].OBUF
+ SLICE[1].RAM8x32.WORD[0].W.B3.q_wire[7] SLICE[1].RAM8x32.WORD[0].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[31] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[0].W.B3.CG SLICE[1].RAM8x32.WORD[0].W.B3.CLK_B
+ SLICE[1].RAM8x32.WORD[0].W.B3.we_wire VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[0].W.B3.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[1].RAM8x32.WORD[0].W.B3.CGAND SLICE[1].RAM8x32.WORD[0].W.B0.SEL
+ SLICE[1].RAM8x32.WORD[0].W.B3.WE VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[0].W.B3.we_wire sky130_fd_sc_hd__and2_1
XSLICE[1].RAM8x32.WORD[0].W.B3.CLKINV SLICE[1].RAM8x32.WORD[0].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[0].W.B3.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[0].W.B3.SELINV SLICE[1].RAM8x32.WORD[0].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[0].W.B3.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[0].W.CLKBUF SLICE[1].RAM8x32.CLK_buf VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[0].W.B0.CLK sky130_fd_sc_hd__clkbuf_1
XSLICE[1].RAM8x32.WORD[0].W.SELBUF SLICE[1].RAM8x32.WORD[0].W.SEL VGND VGND
+ VPWR VPWR SLICE[1].RAM8x32.WORD[0].W.B0.SEL sky130_fd_sc_hd__clkbuf_2
XSLICE[1].RAM8x32.WORD[1].W.B0.BIT[0].LATCH SLICE[0].RAM8x32.Di[0]
+ SLICE[1].RAM8x32.WORD[1].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[1].W.B0.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[1].W.B0.BIT[0].OBUF
+ SLICE[1].RAM8x32.WORD[1].W.B0.q_wire[0] SLICE[1].RAM8x32.WORD[1].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[0] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[1].W.B0.BIT[1].LATCH SLICE[0].RAM8x32.Di[1]
+ SLICE[1].RAM8x32.WORD[1].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[1].W.B0.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[1].W.B0.BIT[1].OBUF
+ SLICE[1].RAM8x32.WORD[1].W.B0.q_wire[1] SLICE[1].RAM8x32.WORD[1].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[1] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[1].W.B0.BIT[2].LATCH SLICE[0].RAM8x32.Di[2]
+ SLICE[1].RAM8x32.WORD[1].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[1].W.B0.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[1].W.B0.BIT[2].OBUF
+ SLICE[1].RAM8x32.WORD[1].W.B0.q_wire[2] SLICE[1].RAM8x32.WORD[1].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[2] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[1].W.B0.BIT[3].LATCH SLICE[0].RAM8x32.Di[3]
+ SLICE[1].RAM8x32.WORD[1].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[1].W.B0.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[1].W.B0.BIT[3].OBUF
+ SLICE[1].RAM8x32.WORD[1].W.B0.q_wire[3] SLICE[1].RAM8x32.WORD[1].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[3] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[1].W.B0.BIT[4].LATCH SLICE[0].RAM8x32.Di[4]
+ SLICE[1].RAM8x32.WORD[1].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[1].W.B0.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[1].W.B0.BIT[4].OBUF
+ SLICE[1].RAM8x32.WORD[1].W.B0.q_wire[4] SLICE[1].RAM8x32.WORD[1].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[4] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[1].W.B0.BIT[5].LATCH SLICE[0].RAM8x32.Di[5]
+ SLICE[1].RAM8x32.WORD[1].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[1].W.B0.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[1].W.B0.BIT[5].OBUF
+ SLICE[1].RAM8x32.WORD[1].W.B0.q_wire[5] SLICE[1].RAM8x32.WORD[1].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[5] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[1].W.B0.BIT[6].LATCH SLICE[0].RAM8x32.Di[6]
+ SLICE[1].RAM8x32.WORD[1].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[1].W.B0.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[1].W.B0.BIT[6].OBUF
+ SLICE[1].RAM8x32.WORD[1].W.B0.q_wire[6] SLICE[1].RAM8x32.WORD[1].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[6] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[1].W.B0.BIT[7].LATCH SLICE[0].RAM8x32.Di[7]
+ SLICE[1].RAM8x32.WORD[1].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[1].W.B0.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[1].W.B0.BIT[7].OBUF
+ SLICE[1].RAM8x32.WORD[1].W.B0.q_wire[7] SLICE[1].RAM8x32.WORD[1].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[7] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[1].W.B0.CG SLICE[1].RAM8x32.WORD[1].W.B0.CLK_B
+ SLICE[1].RAM8x32.WORD[1].W.B0.we_wire VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[1].W.B0.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[1].RAM8x32.WORD[1].W.B0.CGAND SLICE[1].RAM8x32.WORD[1].W.B0.SEL
+ SLICE[1].RAM8x32.WORD[0].W.B0.WE VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[1].W.B0.we_wire sky130_fd_sc_hd__and2_1
XSLICE[1].RAM8x32.WORD[1].W.B0.CLKINV SLICE[1].RAM8x32.WORD[1].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[1].W.B0.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[1].W.B0.SELINV SLICE[1].RAM8x32.WORD[1].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[1].W.B0.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[1].W.B1.BIT[0].LATCH SLICE[0].RAM8x32.Di[8]
+ SLICE[1].RAM8x32.WORD[1].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[1].W.B1.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[1].W.B1.BIT[0].OBUF
+ SLICE[1].RAM8x32.WORD[1].W.B1.q_wire[0] SLICE[1].RAM8x32.WORD[1].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[8] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[1].W.B1.BIT[1].LATCH SLICE[0].RAM8x32.Di[9]
+ SLICE[1].RAM8x32.WORD[1].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[1].W.B1.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[1].W.B1.BIT[1].OBUF
+ SLICE[1].RAM8x32.WORD[1].W.B1.q_wire[1] SLICE[1].RAM8x32.WORD[1].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[9] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[1].W.B1.BIT[2].LATCH SLICE[0].RAM8x32.Di[10]
+ SLICE[1].RAM8x32.WORD[1].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[1].W.B1.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[1].W.B1.BIT[2].OBUF
+ SLICE[1].RAM8x32.WORD[1].W.B1.q_wire[2] SLICE[1].RAM8x32.WORD[1].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[10] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[1].W.B1.BIT[3].LATCH SLICE[0].RAM8x32.Di[11]
+ SLICE[1].RAM8x32.WORD[1].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[1].W.B1.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[1].W.B1.BIT[3].OBUF
+ SLICE[1].RAM8x32.WORD[1].W.B1.q_wire[3] SLICE[1].RAM8x32.WORD[1].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[11] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[1].W.B1.BIT[4].LATCH SLICE[0].RAM8x32.Di[12]
+ SLICE[1].RAM8x32.WORD[1].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[1].W.B1.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[1].W.B1.BIT[4].OBUF
+ SLICE[1].RAM8x32.WORD[1].W.B1.q_wire[4] SLICE[1].RAM8x32.WORD[1].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[12] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[1].W.B1.BIT[5].LATCH SLICE[0].RAM8x32.Di[13]
+ SLICE[1].RAM8x32.WORD[1].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[1].W.B1.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[1].W.B1.BIT[5].OBUF
+ SLICE[1].RAM8x32.WORD[1].W.B1.q_wire[5] SLICE[1].RAM8x32.WORD[1].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[13] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[1].W.B1.BIT[6].LATCH SLICE[0].RAM8x32.Di[14]
+ SLICE[1].RAM8x32.WORD[1].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[1].W.B1.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[1].W.B1.BIT[6].OBUF
+ SLICE[1].RAM8x32.WORD[1].W.B1.q_wire[6] SLICE[1].RAM8x32.WORD[1].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[14] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[1].W.B1.BIT[7].LATCH SLICE[0].RAM8x32.Di[15]
+ SLICE[1].RAM8x32.WORD[1].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[1].W.B1.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[1].W.B1.BIT[7].OBUF
+ SLICE[1].RAM8x32.WORD[1].W.B1.q_wire[7] SLICE[1].RAM8x32.WORD[1].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[15] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[1].W.B1.CG SLICE[1].RAM8x32.WORD[1].W.B1.CLK_B
+ SLICE[1].RAM8x32.WORD[1].W.B1.we_wire VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[1].W.B1.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[1].RAM8x32.WORD[1].W.B1.CGAND SLICE[1].RAM8x32.WORD[1].W.B0.SEL
+ SLICE[1].RAM8x32.WORD[0].W.B1.WE VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[1].W.B1.we_wire sky130_fd_sc_hd__and2_1
XSLICE[1].RAM8x32.WORD[1].W.B1.CLKINV SLICE[1].RAM8x32.WORD[1].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[1].W.B1.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[1].W.B1.SELINV SLICE[1].RAM8x32.WORD[1].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[1].W.B1.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[1].W.B2.BIT[0].LATCH SLICE[0].RAM8x32.Di[16]
+ SLICE[1].RAM8x32.WORD[1].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[1].W.B2.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[1].W.B2.BIT[0].OBUF
+ SLICE[1].RAM8x32.WORD[1].W.B2.q_wire[0] SLICE[1].RAM8x32.WORD[1].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[16] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[1].W.B2.BIT[1].LATCH SLICE[0].RAM8x32.Di[17]
+ SLICE[1].RAM8x32.WORD[1].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[1].W.B2.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[1].W.B2.BIT[1].OBUF
+ SLICE[1].RAM8x32.WORD[1].W.B2.q_wire[1] SLICE[1].RAM8x32.WORD[1].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[17] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[1].W.B2.BIT[2].LATCH SLICE[0].RAM8x32.Di[18]
+ SLICE[1].RAM8x32.WORD[1].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[1].W.B2.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[1].W.B2.BIT[2].OBUF
+ SLICE[1].RAM8x32.WORD[1].W.B2.q_wire[2] SLICE[1].RAM8x32.WORD[1].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[18] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[1].W.B2.BIT[3].LATCH SLICE[0].RAM8x32.Di[19]
+ SLICE[1].RAM8x32.WORD[1].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[1].W.B2.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[1].W.B2.BIT[3].OBUF
+ SLICE[1].RAM8x32.WORD[1].W.B2.q_wire[3] SLICE[1].RAM8x32.WORD[1].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[19] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[1].W.B2.BIT[4].LATCH SLICE[0].RAM8x32.Di[20]
+ SLICE[1].RAM8x32.WORD[1].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[1].W.B2.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[1].W.B2.BIT[4].OBUF
+ SLICE[1].RAM8x32.WORD[1].W.B2.q_wire[4] SLICE[1].RAM8x32.WORD[1].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[20] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[1].W.B2.BIT[5].LATCH SLICE[0].RAM8x32.Di[21]
+ SLICE[1].RAM8x32.WORD[1].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[1].W.B2.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[1].W.B2.BIT[5].OBUF
+ SLICE[1].RAM8x32.WORD[1].W.B2.q_wire[5] SLICE[1].RAM8x32.WORD[1].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[21] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[1].W.B2.BIT[6].LATCH SLICE[0].RAM8x32.Di[22]
+ SLICE[1].RAM8x32.WORD[1].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[1].W.B2.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[1].W.B2.BIT[6].OBUF
+ SLICE[1].RAM8x32.WORD[1].W.B2.q_wire[6] SLICE[1].RAM8x32.WORD[1].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[22] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[1].W.B2.BIT[7].LATCH SLICE[0].RAM8x32.Di[23]
+ SLICE[1].RAM8x32.WORD[1].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[1].W.B2.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[1].W.B2.BIT[7].OBUF
+ SLICE[1].RAM8x32.WORD[1].W.B2.q_wire[7] SLICE[1].RAM8x32.WORD[1].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[23] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[1].W.B2.CG SLICE[1].RAM8x32.WORD[1].W.B2.CLK_B
+ SLICE[1].RAM8x32.WORD[1].W.B2.we_wire VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[1].W.B2.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[1].RAM8x32.WORD[1].W.B2.CGAND SLICE[1].RAM8x32.WORD[1].W.B0.SEL
+ SLICE[1].RAM8x32.WORD[0].W.B2.WE VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[1].W.B2.we_wire sky130_fd_sc_hd__and2_1
XSLICE[1].RAM8x32.WORD[1].W.B2.CLKINV SLICE[1].RAM8x32.WORD[1].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[1].W.B2.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[1].W.B2.SELINV SLICE[1].RAM8x32.WORD[1].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[1].W.B2.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[1].W.B3.BIT[0].LATCH SLICE[0].RAM8x32.Di[24]
+ SLICE[1].RAM8x32.WORD[1].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[1].W.B3.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[1].W.B3.BIT[0].OBUF
+ SLICE[1].RAM8x32.WORD[1].W.B3.q_wire[0] SLICE[1].RAM8x32.WORD[1].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[24] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[1].W.B3.BIT[1].LATCH SLICE[0].RAM8x32.Di[25]
+ SLICE[1].RAM8x32.WORD[1].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[1].W.B3.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[1].W.B3.BIT[1].OBUF
+ SLICE[1].RAM8x32.WORD[1].W.B3.q_wire[1] SLICE[1].RAM8x32.WORD[1].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[25] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[1].W.B3.BIT[2].LATCH SLICE[0].RAM8x32.Di[26]
+ SLICE[1].RAM8x32.WORD[1].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[1].W.B3.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[1].W.B3.BIT[2].OBUF
+ SLICE[1].RAM8x32.WORD[1].W.B3.q_wire[2] SLICE[1].RAM8x32.WORD[1].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[26] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[1].W.B3.BIT[3].LATCH SLICE[0].RAM8x32.Di[27]
+ SLICE[1].RAM8x32.WORD[1].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[1].W.B3.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[1].W.B3.BIT[3].OBUF
+ SLICE[1].RAM8x32.WORD[1].W.B3.q_wire[3] SLICE[1].RAM8x32.WORD[1].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[27] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[1].W.B3.BIT[4].LATCH SLICE[0].RAM8x32.Di[28]
+ SLICE[1].RAM8x32.WORD[1].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[1].W.B3.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[1].W.B3.BIT[4].OBUF
+ SLICE[1].RAM8x32.WORD[1].W.B3.q_wire[4] SLICE[1].RAM8x32.WORD[1].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[28] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[1].W.B3.BIT[5].LATCH SLICE[0].RAM8x32.Di[29]
+ SLICE[1].RAM8x32.WORD[1].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[1].W.B3.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[1].W.B3.BIT[5].OBUF
+ SLICE[1].RAM8x32.WORD[1].W.B3.q_wire[5] SLICE[1].RAM8x32.WORD[1].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[29] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[1].W.B3.BIT[6].LATCH SLICE[0].RAM8x32.Di[30]
+ SLICE[1].RAM8x32.WORD[1].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[1].W.B3.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[1].W.B3.BIT[6].OBUF
+ SLICE[1].RAM8x32.WORD[1].W.B3.q_wire[6] SLICE[1].RAM8x32.WORD[1].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[30] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[1].W.B3.BIT[7].LATCH SLICE[0].RAM8x32.Di[31]
+ SLICE[1].RAM8x32.WORD[1].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[1].W.B3.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[1].W.B3.BIT[7].OBUF
+ SLICE[1].RAM8x32.WORD[1].W.B3.q_wire[7] SLICE[1].RAM8x32.WORD[1].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[31] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[1].W.B3.CG SLICE[1].RAM8x32.WORD[1].W.B3.CLK_B
+ SLICE[1].RAM8x32.WORD[1].W.B3.we_wire VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[1].W.B3.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[1].RAM8x32.WORD[1].W.B3.CGAND SLICE[1].RAM8x32.WORD[1].W.B0.SEL
+ SLICE[1].RAM8x32.WORD[0].W.B3.WE VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[1].W.B3.we_wire sky130_fd_sc_hd__and2_1
XSLICE[1].RAM8x32.WORD[1].W.B3.CLKINV SLICE[1].RAM8x32.WORD[1].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[1].W.B3.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[1].W.B3.SELINV SLICE[1].RAM8x32.WORD[1].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[1].W.B3.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[1].W.CLKBUF SLICE[1].RAM8x32.CLK_buf VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[1].W.B0.CLK sky130_fd_sc_hd__clkbuf_1
XSLICE[1].RAM8x32.WORD[1].W.SELBUF SLICE[1].RAM8x32.WORD[1].W.SEL VGND VGND
+ VPWR VPWR SLICE[1].RAM8x32.WORD[1].W.B0.SEL sky130_fd_sc_hd__clkbuf_2
XSLICE[1].RAM8x32.WORD[2].W.B0.BIT[0].LATCH SLICE[0].RAM8x32.Di[0]
+ SLICE[1].RAM8x32.WORD[2].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[2].W.B0.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[2].W.B0.BIT[0].OBUF
+ SLICE[1].RAM8x32.WORD[2].W.B0.q_wire[0] SLICE[1].RAM8x32.WORD[2].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[0] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[2].W.B0.BIT[1].LATCH SLICE[0].RAM8x32.Di[1]
+ SLICE[1].RAM8x32.WORD[2].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[2].W.B0.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[2].W.B0.BIT[1].OBUF
+ SLICE[1].RAM8x32.WORD[2].W.B0.q_wire[1] SLICE[1].RAM8x32.WORD[2].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[1] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[2].W.B0.BIT[2].LATCH SLICE[0].RAM8x32.Di[2]
+ SLICE[1].RAM8x32.WORD[2].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[2].W.B0.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[2].W.B0.BIT[2].OBUF
+ SLICE[1].RAM8x32.WORD[2].W.B0.q_wire[2] SLICE[1].RAM8x32.WORD[2].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[2] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[2].W.B0.BIT[3].LATCH SLICE[0].RAM8x32.Di[3]
+ SLICE[1].RAM8x32.WORD[2].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[2].W.B0.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[2].W.B0.BIT[3].OBUF
+ SLICE[1].RAM8x32.WORD[2].W.B0.q_wire[3] SLICE[1].RAM8x32.WORD[2].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[3] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[2].W.B0.BIT[4].LATCH SLICE[0].RAM8x32.Di[4]
+ SLICE[1].RAM8x32.WORD[2].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[2].W.B0.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[2].W.B0.BIT[4].OBUF
+ SLICE[1].RAM8x32.WORD[2].W.B0.q_wire[4] SLICE[1].RAM8x32.WORD[2].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[4] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[2].W.B0.BIT[5].LATCH SLICE[0].RAM8x32.Di[5]
+ SLICE[1].RAM8x32.WORD[2].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[2].W.B0.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[2].W.B0.BIT[5].OBUF
+ SLICE[1].RAM8x32.WORD[2].W.B0.q_wire[5] SLICE[1].RAM8x32.WORD[2].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[5] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[2].W.B0.BIT[6].LATCH SLICE[0].RAM8x32.Di[6]
+ SLICE[1].RAM8x32.WORD[2].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[2].W.B0.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[2].W.B0.BIT[6].OBUF
+ SLICE[1].RAM8x32.WORD[2].W.B0.q_wire[6] SLICE[1].RAM8x32.WORD[2].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[6] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[2].W.B0.BIT[7].LATCH SLICE[0].RAM8x32.Di[7]
+ SLICE[1].RAM8x32.WORD[2].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[2].W.B0.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[2].W.B0.BIT[7].OBUF
+ SLICE[1].RAM8x32.WORD[2].W.B0.q_wire[7] SLICE[1].RAM8x32.WORD[2].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[7] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[2].W.B0.CG SLICE[1].RAM8x32.WORD[2].W.B0.CLK_B
+ SLICE[1].RAM8x32.WORD[2].W.B0.we_wire VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[2].W.B0.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[1].RAM8x32.WORD[2].W.B0.CGAND SLICE[1].RAM8x32.WORD[2].W.B0.SEL
+ SLICE[1].RAM8x32.WORD[0].W.B0.WE VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[2].W.B0.we_wire sky130_fd_sc_hd__and2_1
XSLICE[1].RAM8x32.WORD[2].W.B0.CLKINV SLICE[1].RAM8x32.WORD[2].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[2].W.B0.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[2].W.B0.SELINV SLICE[1].RAM8x32.WORD[2].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[2].W.B0.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[2].W.B1.BIT[0].LATCH SLICE[0].RAM8x32.Di[8]
+ SLICE[1].RAM8x32.WORD[2].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[2].W.B1.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[2].W.B1.BIT[0].OBUF
+ SLICE[1].RAM8x32.WORD[2].W.B1.q_wire[0] SLICE[1].RAM8x32.WORD[2].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[8] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[2].W.B1.BIT[1].LATCH SLICE[0].RAM8x32.Di[9]
+ SLICE[1].RAM8x32.WORD[2].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[2].W.B1.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[2].W.B1.BIT[1].OBUF
+ SLICE[1].RAM8x32.WORD[2].W.B1.q_wire[1] SLICE[1].RAM8x32.WORD[2].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[9] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[2].W.B1.BIT[2].LATCH SLICE[0].RAM8x32.Di[10]
+ SLICE[1].RAM8x32.WORD[2].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[2].W.B1.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[2].W.B1.BIT[2].OBUF
+ SLICE[1].RAM8x32.WORD[2].W.B1.q_wire[2] SLICE[1].RAM8x32.WORD[2].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[10] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[2].W.B1.BIT[3].LATCH SLICE[0].RAM8x32.Di[11]
+ SLICE[1].RAM8x32.WORD[2].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[2].W.B1.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[2].W.B1.BIT[3].OBUF
+ SLICE[1].RAM8x32.WORD[2].W.B1.q_wire[3] SLICE[1].RAM8x32.WORD[2].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[11] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[2].W.B1.BIT[4].LATCH SLICE[0].RAM8x32.Di[12]
+ SLICE[1].RAM8x32.WORD[2].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[2].W.B1.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[2].W.B1.BIT[4].OBUF
+ SLICE[1].RAM8x32.WORD[2].W.B1.q_wire[4] SLICE[1].RAM8x32.WORD[2].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[12] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[2].W.B1.BIT[5].LATCH SLICE[0].RAM8x32.Di[13]
+ SLICE[1].RAM8x32.WORD[2].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[2].W.B1.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[2].W.B1.BIT[5].OBUF
+ SLICE[1].RAM8x32.WORD[2].W.B1.q_wire[5] SLICE[1].RAM8x32.WORD[2].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[13] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[2].W.B1.BIT[6].LATCH SLICE[0].RAM8x32.Di[14]
+ SLICE[1].RAM8x32.WORD[2].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[2].W.B1.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[2].W.B1.BIT[6].OBUF
+ SLICE[1].RAM8x32.WORD[2].W.B1.q_wire[6] SLICE[1].RAM8x32.WORD[2].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[14] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[2].W.B1.BIT[7].LATCH SLICE[0].RAM8x32.Di[15]
+ SLICE[1].RAM8x32.WORD[2].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[2].W.B1.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[2].W.B1.BIT[7].OBUF
+ SLICE[1].RAM8x32.WORD[2].W.B1.q_wire[7] SLICE[1].RAM8x32.WORD[2].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[15] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[2].W.B1.CG SLICE[1].RAM8x32.WORD[2].W.B1.CLK_B
+ SLICE[1].RAM8x32.WORD[2].W.B1.we_wire VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[2].W.B1.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[1].RAM8x32.WORD[2].W.B1.CGAND SLICE[1].RAM8x32.WORD[2].W.B0.SEL
+ SLICE[1].RAM8x32.WORD[0].W.B1.WE VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[2].W.B1.we_wire sky130_fd_sc_hd__and2_1
XSLICE[1].RAM8x32.WORD[2].W.B1.CLKINV SLICE[1].RAM8x32.WORD[2].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[2].W.B1.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[2].W.B1.SELINV SLICE[1].RAM8x32.WORD[2].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[2].W.B1.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[2].W.B2.BIT[0].LATCH SLICE[0].RAM8x32.Di[16]
+ SLICE[1].RAM8x32.WORD[2].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[2].W.B2.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[2].W.B2.BIT[0].OBUF
+ SLICE[1].RAM8x32.WORD[2].W.B2.q_wire[0] SLICE[1].RAM8x32.WORD[2].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[16] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[2].W.B2.BIT[1].LATCH SLICE[0].RAM8x32.Di[17]
+ SLICE[1].RAM8x32.WORD[2].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[2].W.B2.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[2].W.B2.BIT[1].OBUF
+ SLICE[1].RAM8x32.WORD[2].W.B2.q_wire[1] SLICE[1].RAM8x32.WORD[2].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[17] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[2].W.B2.BIT[2].LATCH SLICE[0].RAM8x32.Di[18]
+ SLICE[1].RAM8x32.WORD[2].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[2].W.B2.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[2].W.B2.BIT[2].OBUF
+ SLICE[1].RAM8x32.WORD[2].W.B2.q_wire[2] SLICE[1].RAM8x32.WORD[2].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[18] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[2].W.B2.BIT[3].LATCH SLICE[0].RAM8x32.Di[19]
+ SLICE[1].RAM8x32.WORD[2].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[2].W.B2.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[2].W.B2.BIT[3].OBUF
+ SLICE[1].RAM8x32.WORD[2].W.B2.q_wire[3] SLICE[1].RAM8x32.WORD[2].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[19] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[2].W.B2.BIT[4].LATCH SLICE[0].RAM8x32.Di[20]
+ SLICE[1].RAM8x32.WORD[2].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[2].W.B2.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[2].W.B2.BIT[4].OBUF
+ SLICE[1].RAM8x32.WORD[2].W.B2.q_wire[4] SLICE[1].RAM8x32.WORD[2].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[20] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[2].W.B2.BIT[5].LATCH SLICE[0].RAM8x32.Di[21]
+ SLICE[1].RAM8x32.WORD[2].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[2].W.B2.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[2].W.B2.BIT[5].OBUF
+ SLICE[1].RAM8x32.WORD[2].W.B2.q_wire[5] SLICE[1].RAM8x32.WORD[2].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[21] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[2].W.B2.BIT[6].LATCH SLICE[0].RAM8x32.Di[22]
+ SLICE[1].RAM8x32.WORD[2].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[2].W.B2.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[2].W.B2.BIT[6].OBUF
+ SLICE[1].RAM8x32.WORD[2].W.B2.q_wire[6] SLICE[1].RAM8x32.WORD[2].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[22] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[2].W.B2.BIT[7].LATCH SLICE[0].RAM8x32.Di[23]
+ SLICE[1].RAM8x32.WORD[2].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[2].W.B2.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[2].W.B2.BIT[7].OBUF
+ SLICE[1].RAM8x32.WORD[2].W.B2.q_wire[7] SLICE[1].RAM8x32.WORD[2].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[23] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[2].W.B2.CG SLICE[1].RAM8x32.WORD[2].W.B2.CLK_B
+ SLICE[1].RAM8x32.WORD[2].W.B2.we_wire VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[2].W.B2.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[1].RAM8x32.WORD[2].W.B2.CGAND SLICE[1].RAM8x32.WORD[2].W.B0.SEL
+ SLICE[1].RAM8x32.WORD[0].W.B2.WE VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[2].W.B2.we_wire sky130_fd_sc_hd__and2_1
XSLICE[1].RAM8x32.WORD[2].W.B2.CLKINV SLICE[1].RAM8x32.WORD[2].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[2].W.B2.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[2].W.B2.SELINV SLICE[1].RAM8x32.WORD[2].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[2].W.B2.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[2].W.B3.BIT[0].LATCH SLICE[0].RAM8x32.Di[24]
+ SLICE[1].RAM8x32.WORD[2].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[2].W.B3.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[2].W.B3.BIT[0].OBUF
+ SLICE[1].RAM8x32.WORD[2].W.B3.q_wire[0] SLICE[1].RAM8x32.WORD[2].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[24] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[2].W.B3.BIT[1].LATCH SLICE[0].RAM8x32.Di[25]
+ SLICE[1].RAM8x32.WORD[2].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[2].W.B3.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[2].W.B3.BIT[1].OBUF
+ SLICE[1].RAM8x32.WORD[2].W.B3.q_wire[1] SLICE[1].RAM8x32.WORD[2].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[25] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[2].W.B3.BIT[2].LATCH SLICE[0].RAM8x32.Di[26]
+ SLICE[1].RAM8x32.WORD[2].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[2].W.B3.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[2].W.B3.BIT[2].OBUF
+ SLICE[1].RAM8x32.WORD[2].W.B3.q_wire[2] SLICE[1].RAM8x32.WORD[2].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[26] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[2].W.B3.BIT[3].LATCH SLICE[0].RAM8x32.Di[27]
+ SLICE[1].RAM8x32.WORD[2].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[2].W.B3.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[2].W.B3.BIT[3].OBUF
+ SLICE[1].RAM8x32.WORD[2].W.B3.q_wire[3] SLICE[1].RAM8x32.WORD[2].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[27] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[2].W.B3.BIT[4].LATCH SLICE[0].RAM8x32.Di[28]
+ SLICE[1].RAM8x32.WORD[2].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[2].W.B3.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[2].W.B3.BIT[4].OBUF
+ SLICE[1].RAM8x32.WORD[2].W.B3.q_wire[4] SLICE[1].RAM8x32.WORD[2].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[28] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[2].W.B3.BIT[5].LATCH SLICE[0].RAM8x32.Di[29]
+ SLICE[1].RAM8x32.WORD[2].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[2].W.B3.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[2].W.B3.BIT[5].OBUF
+ SLICE[1].RAM8x32.WORD[2].W.B3.q_wire[5] SLICE[1].RAM8x32.WORD[2].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[29] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[2].W.B3.BIT[6].LATCH SLICE[0].RAM8x32.Di[30]
+ SLICE[1].RAM8x32.WORD[2].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[2].W.B3.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[2].W.B3.BIT[6].OBUF
+ SLICE[1].RAM8x32.WORD[2].W.B3.q_wire[6] SLICE[1].RAM8x32.WORD[2].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[30] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[2].W.B3.BIT[7].LATCH SLICE[0].RAM8x32.Di[31]
+ SLICE[1].RAM8x32.WORD[2].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[2].W.B3.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[2].W.B3.BIT[7].OBUF
+ SLICE[1].RAM8x32.WORD[2].W.B3.q_wire[7] SLICE[1].RAM8x32.WORD[2].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[31] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[2].W.B3.CG SLICE[1].RAM8x32.WORD[2].W.B3.CLK_B
+ SLICE[1].RAM8x32.WORD[2].W.B3.we_wire VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[2].W.B3.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[1].RAM8x32.WORD[2].W.B3.CGAND SLICE[1].RAM8x32.WORD[2].W.B0.SEL
+ SLICE[1].RAM8x32.WORD[0].W.B3.WE VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[2].W.B3.we_wire sky130_fd_sc_hd__and2_1
XSLICE[1].RAM8x32.WORD[2].W.B3.CLKINV SLICE[1].RAM8x32.WORD[2].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[2].W.B3.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[2].W.B3.SELINV SLICE[1].RAM8x32.WORD[2].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[2].W.B3.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[2].W.CLKBUF SLICE[1].RAM8x32.CLK_buf VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[2].W.B0.CLK sky130_fd_sc_hd__clkbuf_1
XSLICE[1].RAM8x32.WORD[2].W.SELBUF SLICE[1].RAM8x32.WORD[2].W.SEL VGND VGND
+ VPWR VPWR SLICE[1].RAM8x32.WORD[2].W.B0.SEL sky130_fd_sc_hd__clkbuf_2
XSLICE[1].RAM8x32.WORD[3].W.B0.BIT[0].LATCH SLICE[0].RAM8x32.Di[0]
+ SLICE[1].RAM8x32.WORD[3].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[3].W.B0.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[3].W.B0.BIT[0].OBUF
+ SLICE[1].RAM8x32.WORD[3].W.B0.q_wire[0] SLICE[1].RAM8x32.WORD[3].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[0] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[3].W.B0.BIT[1].LATCH SLICE[0].RAM8x32.Di[1]
+ SLICE[1].RAM8x32.WORD[3].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[3].W.B0.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[3].W.B0.BIT[1].OBUF
+ SLICE[1].RAM8x32.WORD[3].W.B0.q_wire[1] SLICE[1].RAM8x32.WORD[3].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[1] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[3].W.B0.BIT[2].LATCH SLICE[0].RAM8x32.Di[2]
+ SLICE[1].RAM8x32.WORD[3].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[3].W.B0.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[3].W.B0.BIT[2].OBUF
+ SLICE[1].RAM8x32.WORD[3].W.B0.q_wire[2] SLICE[1].RAM8x32.WORD[3].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[2] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[3].W.B0.BIT[3].LATCH SLICE[0].RAM8x32.Di[3]
+ SLICE[1].RAM8x32.WORD[3].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[3].W.B0.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[3].W.B0.BIT[3].OBUF
+ SLICE[1].RAM8x32.WORD[3].W.B0.q_wire[3] SLICE[1].RAM8x32.WORD[3].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[3] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[3].W.B0.BIT[4].LATCH SLICE[0].RAM8x32.Di[4]
+ SLICE[1].RAM8x32.WORD[3].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[3].W.B0.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[3].W.B0.BIT[4].OBUF
+ SLICE[1].RAM8x32.WORD[3].W.B0.q_wire[4] SLICE[1].RAM8x32.WORD[3].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[4] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[3].W.B0.BIT[5].LATCH SLICE[0].RAM8x32.Di[5]
+ SLICE[1].RAM8x32.WORD[3].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[3].W.B0.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[3].W.B0.BIT[5].OBUF
+ SLICE[1].RAM8x32.WORD[3].W.B0.q_wire[5] SLICE[1].RAM8x32.WORD[3].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[5] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[3].W.B0.BIT[6].LATCH SLICE[0].RAM8x32.Di[6]
+ SLICE[1].RAM8x32.WORD[3].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[3].W.B0.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[3].W.B0.BIT[6].OBUF
+ SLICE[1].RAM8x32.WORD[3].W.B0.q_wire[6] SLICE[1].RAM8x32.WORD[3].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[6] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[3].W.B0.BIT[7].LATCH SLICE[0].RAM8x32.Di[7]
+ SLICE[1].RAM8x32.WORD[3].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[3].W.B0.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[3].W.B0.BIT[7].OBUF
+ SLICE[1].RAM8x32.WORD[3].W.B0.q_wire[7] SLICE[1].RAM8x32.WORD[3].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[7] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[3].W.B0.CG SLICE[1].RAM8x32.WORD[3].W.B0.CLK_B
+ SLICE[1].RAM8x32.WORD[3].W.B0.we_wire VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[3].W.B0.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[1].RAM8x32.WORD[3].W.B0.CGAND SLICE[1].RAM8x32.WORD[3].W.B0.SEL
+ SLICE[1].RAM8x32.WORD[0].W.B0.WE VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[3].W.B0.we_wire sky130_fd_sc_hd__and2_1
XSLICE[1].RAM8x32.WORD[3].W.B0.CLKINV SLICE[1].RAM8x32.WORD[3].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[3].W.B0.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[3].W.B0.SELINV SLICE[1].RAM8x32.WORD[3].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[3].W.B0.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[3].W.B1.BIT[0].LATCH SLICE[0].RAM8x32.Di[8]
+ SLICE[1].RAM8x32.WORD[3].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[3].W.B1.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[3].W.B1.BIT[0].OBUF
+ SLICE[1].RAM8x32.WORD[3].W.B1.q_wire[0] SLICE[1].RAM8x32.WORD[3].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[8] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[3].W.B1.BIT[1].LATCH SLICE[0].RAM8x32.Di[9]
+ SLICE[1].RAM8x32.WORD[3].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[3].W.B1.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[3].W.B1.BIT[1].OBUF
+ SLICE[1].RAM8x32.WORD[3].W.B1.q_wire[1] SLICE[1].RAM8x32.WORD[3].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[9] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[3].W.B1.BIT[2].LATCH SLICE[0].RAM8x32.Di[10]
+ SLICE[1].RAM8x32.WORD[3].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[3].W.B1.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[3].W.B1.BIT[2].OBUF
+ SLICE[1].RAM8x32.WORD[3].W.B1.q_wire[2] SLICE[1].RAM8x32.WORD[3].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[10] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[3].W.B1.BIT[3].LATCH SLICE[0].RAM8x32.Di[11]
+ SLICE[1].RAM8x32.WORD[3].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[3].W.B1.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[3].W.B1.BIT[3].OBUF
+ SLICE[1].RAM8x32.WORD[3].W.B1.q_wire[3] SLICE[1].RAM8x32.WORD[3].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[11] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[3].W.B1.BIT[4].LATCH SLICE[0].RAM8x32.Di[12]
+ SLICE[1].RAM8x32.WORD[3].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[3].W.B1.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[3].W.B1.BIT[4].OBUF
+ SLICE[1].RAM8x32.WORD[3].W.B1.q_wire[4] SLICE[1].RAM8x32.WORD[3].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[12] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[3].W.B1.BIT[5].LATCH SLICE[0].RAM8x32.Di[13]
+ SLICE[1].RAM8x32.WORD[3].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[3].W.B1.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[3].W.B1.BIT[5].OBUF
+ SLICE[1].RAM8x32.WORD[3].W.B1.q_wire[5] SLICE[1].RAM8x32.WORD[3].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[13] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[3].W.B1.BIT[6].LATCH SLICE[0].RAM8x32.Di[14]
+ SLICE[1].RAM8x32.WORD[3].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[3].W.B1.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[3].W.B1.BIT[6].OBUF
+ SLICE[1].RAM8x32.WORD[3].W.B1.q_wire[6] SLICE[1].RAM8x32.WORD[3].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[14] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[3].W.B1.BIT[7].LATCH SLICE[0].RAM8x32.Di[15]
+ SLICE[1].RAM8x32.WORD[3].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[3].W.B1.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[3].W.B1.BIT[7].OBUF
+ SLICE[1].RAM8x32.WORD[3].W.B1.q_wire[7] SLICE[1].RAM8x32.WORD[3].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[15] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[3].W.B1.CG SLICE[1].RAM8x32.WORD[3].W.B1.CLK_B
+ SLICE[1].RAM8x32.WORD[3].W.B1.we_wire VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[3].W.B1.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[1].RAM8x32.WORD[3].W.B1.CGAND SLICE[1].RAM8x32.WORD[3].W.B0.SEL
+ SLICE[1].RAM8x32.WORD[0].W.B1.WE VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[3].W.B1.we_wire sky130_fd_sc_hd__and2_1
XSLICE[1].RAM8x32.WORD[3].W.B1.CLKINV SLICE[1].RAM8x32.WORD[3].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[3].W.B1.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[3].W.B1.SELINV SLICE[1].RAM8x32.WORD[3].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[3].W.B1.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[3].W.B2.BIT[0].LATCH SLICE[0].RAM8x32.Di[16]
+ SLICE[1].RAM8x32.WORD[3].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[3].W.B2.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[3].W.B2.BIT[0].OBUF
+ SLICE[1].RAM8x32.WORD[3].W.B2.q_wire[0] SLICE[1].RAM8x32.WORD[3].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[16] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[3].W.B2.BIT[1].LATCH SLICE[0].RAM8x32.Di[17]
+ SLICE[1].RAM8x32.WORD[3].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[3].W.B2.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[3].W.B2.BIT[1].OBUF
+ SLICE[1].RAM8x32.WORD[3].W.B2.q_wire[1] SLICE[1].RAM8x32.WORD[3].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[17] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[3].W.B2.BIT[2].LATCH SLICE[0].RAM8x32.Di[18]
+ SLICE[1].RAM8x32.WORD[3].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[3].W.B2.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[3].W.B2.BIT[2].OBUF
+ SLICE[1].RAM8x32.WORD[3].W.B2.q_wire[2] SLICE[1].RAM8x32.WORD[3].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[18] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[3].W.B2.BIT[3].LATCH SLICE[0].RAM8x32.Di[19]
+ SLICE[1].RAM8x32.WORD[3].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[3].W.B2.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[3].W.B2.BIT[3].OBUF
+ SLICE[1].RAM8x32.WORD[3].W.B2.q_wire[3] SLICE[1].RAM8x32.WORD[3].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[19] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[3].W.B2.BIT[4].LATCH SLICE[0].RAM8x32.Di[20]
+ SLICE[1].RAM8x32.WORD[3].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[3].W.B2.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[3].W.B2.BIT[4].OBUF
+ SLICE[1].RAM8x32.WORD[3].W.B2.q_wire[4] SLICE[1].RAM8x32.WORD[3].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[20] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[3].W.B2.BIT[5].LATCH SLICE[0].RAM8x32.Di[21]
+ SLICE[1].RAM8x32.WORD[3].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[3].W.B2.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[3].W.B2.BIT[5].OBUF
+ SLICE[1].RAM8x32.WORD[3].W.B2.q_wire[5] SLICE[1].RAM8x32.WORD[3].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[21] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[3].W.B2.BIT[6].LATCH SLICE[0].RAM8x32.Di[22]
+ SLICE[1].RAM8x32.WORD[3].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[3].W.B2.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[3].W.B2.BIT[6].OBUF
+ SLICE[1].RAM8x32.WORD[3].W.B2.q_wire[6] SLICE[1].RAM8x32.WORD[3].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[22] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[3].W.B2.BIT[7].LATCH SLICE[0].RAM8x32.Di[23]
+ SLICE[1].RAM8x32.WORD[3].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[3].W.B2.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[3].W.B2.BIT[7].OBUF
+ SLICE[1].RAM8x32.WORD[3].W.B2.q_wire[7] SLICE[1].RAM8x32.WORD[3].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[23] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[3].W.B2.CG SLICE[1].RAM8x32.WORD[3].W.B2.CLK_B
+ SLICE[1].RAM8x32.WORD[3].W.B2.we_wire VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[3].W.B2.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[1].RAM8x32.WORD[3].W.B2.CGAND SLICE[1].RAM8x32.WORD[3].W.B0.SEL
+ SLICE[1].RAM8x32.WORD[0].W.B2.WE VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[3].W.B2.we_wire sky130_fd_sc_hd__and2_1
XSLICE[1].RAM8x32.WORD[3].W.B2.CLKINV SLICE[1].RAM8x32.WORD[3].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[3].W.B2.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[3].W.B2.SELINV SLICE[1].RAM8x32.WORD[3].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[3].W.B2.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[3].W.B3.BIT[0].LATCH SLICE[0].RAM8x32.Di[24]
+ SLICE[1].RAM8x32.WORD[3].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[3].W.B3.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[3].W.B3.BIT[0].OBUF
+ SLICE[1].RAM8x32.WORD[3].W.B3.q_wire[0] SLICE[1].RAM8x32.WORD[3].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[24] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[3].W.B3.BIT[1].LATCH SLICE[0].RAM8x32.Di[25]
+ SLICE[1].RAM8x32.WORD[3].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[3].W.B3.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[3].W.B3.BIT[1].OBUF
+ SLICE[1].RAM8x32.WORD[3].W.B3.q_wire[1] SLICE[1].RAM8x32.WORD[3].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[25] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[3].W.B3.BIT[2].LATCH SLICE[0].RAM8x32.Di[26]
+ SLICE[1].RAM8x32.WORD[3].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[3].W.B3.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[3].W.B3.BIT[2].OBUF
+ SLICE[1].RAM8x32.WORD[3].W.B3.q_wire[2] SLICE[1].RAM8x32.WORD[3].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[26] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[3].W.B3.BIT[3].LATCH SLICE[0].RAM8x32.Di[27]
+ SLICE[1].RAM8x32.WORD[3].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[3].W.B3.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[3].W.B3.BIT[3].OBUF
+ SLICE[1].RAM8x32.WORD[3].W.B3.q_wire[3] SLICE[1].RAM8x32.WORD[3].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[27] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[3].W.B3.BIT[4].LATCH SLICE[0].RAM8x32.Di[28]
+ SLICE[1].RAM8x32.WORD[3].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[3].W.B3.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[3].W.B3.BIT[4].OBUF
+ SLICE[1].RAM8x32.WORD[3].W.B3.q_wire[4] SLICE[1].RAM8x32.WORD[3].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[28] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[3].W.B3.BIT[5].LATCH SLICE[0].RAM8x32.Di[29]
+ SLICE[1].RAM8x32.WORD[3].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[3].W.B3.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[3].W.B3.BIT[5].OBUF
+ SLICE[1].RAM8x32.WORD[3].W.B3.q_wire[5] SLICE[1].RAM8x32.WORD[3].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[29] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[3].W.B3.BIT[6].LATCH SLICE[0].RAM8x32.Di[30]
+ SLICE[1].RAM8x32.WORD[3].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[3].W.B3.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[3].W.B3.BIT[6].OBUF
+ SLICE[1].RAM8x32.WORD[3].W.B3.q_wire[6] SLICE[1].RAM8x32.WORD[3].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[30] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[3].W.B3.BIT[7].LATCH SLICE[0].RAM8x32.Di[31]
+ SLICE[1].RAM8x32.WORD[3].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[3].W.B3.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[3].W.B3.BIT[7].OBUF
+ SLICE[1].RAM8x32.WORD[3].W.B3.q_wire[7] SLICE[1].RAM8x32.WORD[3].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[31] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[3].W.B3.CG SLICE[1].RAM8x32.WORD[3].W.B3.CLK_B
+ SLICE[1].RAM8x32.WORD[3].W.B3.we_wire VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[3].W.B3.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[1].RAM8x32.WORD[3].W.B3.CGAND SLICE[1].RAM8x32.WORD[3].W.B0.SEL
+ SLICE[1].RAM8x32.WORD[0].W.B3.WE VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[3].W.B3.we_wire sky130_fd_sc_hd__and2_1
XSLICE[1].RAM8x32.WORD[3].W.B3.CLKINV SLICE[1].RAM8x32.WORD[3].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[3].W.B3.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[3].W.B3.SELINV SLICE[1].RAM8x32.WORD[3].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[3].W.B3.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[3].W.CLKBUF SLICE[1].RAM8x32.CLK_buf VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[3].W.B0.CLK sky130_fd_sc_hd__clkbuf_1
XSLICE[1].RAM8x32.WORD[3].W.SELBUF SLICE[1].RAM8x32.WORD[3].W.SEL VGND VGND
+ VPWR VPWR SLICE[1].RAM8x32.WORD[3].W.B0.SEL sky130_fd_sc_hd__clkbuf_2
XSLICE[1].RAM8x32.WORD[4].W.B0.BIT[0].LATCH SLICE[0].RAM8x32.Di[0]
+ SLICE[1].RAM8x32.WORD[4].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[4].W.B0.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[4].W.B0.BIT[0].OBUF
+ SLICE[1].RAM8x32.WORD[4].W.B0.q_wire[0] SLICE[1].RAM8x32.WORD[4].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[0] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[4].W.B0.BIT[1].LATCH SLICE[0].RAM8x32.Di[1]
+ SLICE[1].RAM8x32.WORD[4].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[4].W.B0.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[4].W.B0.BIT[1].OBUF
+ SLICE[1].RAM8x32.WORD[4].W.B0.q_wire[1] SLICE[1].RAM8x32.WORD[4].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[1] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[4].W.B0.BIT[2].LATCH SLICE[0].RAM8x32.Di[2]
+ SLICE[1].RAM8x32.WORD[4].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[4].W.B0.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[4].W.B0.BIT[2].OBUF
+ SLICE[1].RAM8x32.WORD[4].W.B0.q_wire[2] SLICE[1].RAM8x32.WORD[4].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[2] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[4].W.B0.BIT[3].LATCH SLICE[0].RAM8x32.Di[3]
+ SLICE[1].RAM8x32.WORD[4].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[4].W.B0.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[4].W.B0.BIT[3].OBUF
+ SLICE[1].RAM8x32.WORD[4].W.B0.q_wire[3] SLICE[1].RAM8x32.WORD[4].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[3] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[4].W.B0.BIT[4].LATCH SLICE[0].RAM8x32.Di[4]
+ SLICE[1].RAM8x32.WORD[4].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[4].W.B0.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[4].W.B0.BIT[4].OBUF
+ SLICE[1].RAM8x32.WORD[4].W.B0.q_wire[4] SLICE[1].RAM8x32.WORD[4].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[4] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[4].W.B0.BIT[5].LATCH SLICE[0].RAM8x32.Di[5]
+ SLICE[1].RAM8x32.WORD[4].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[4].W.B0.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[4].W.B0.BIT[5].OBUF
+ SLICE[1].RAM8x32.WORD[4].W.B0.q_wire[5] SLICE[1].RAM8x32.WORD[4].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[5] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[4].W.B0.BIT[6].LATCH SLICE[0].RAM8x32.Di[6]
+ SLICE[1].RAM8x32.WORD[4].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[4].W.B0.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[4].W.B0.BIT[6].OBUF
+ SLICE[1].RAM8x32.WORD[4].W.B0.q_wire[6] SLICE[1].RAM8x32.WORD[4].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[6] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[4].W.B0.BIT[7].LATCH SLICE[0].RAM8x32.Di[7]
+ SLICE[1].RAM8x32.WORD[4].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[4].W.B0.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[4].W.B0.BIT[7].OBUF
+ SLICE[1].RAM8x32.WORD[4].W.B0.q_wire[7] SLICE[1].RAM8x32.WORD[4].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[7] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[4].W.B0.CG SLICE[1].RAM8x32.WORD[4].W.B0.CLK_B
+ SLICE[1].RAM8x32.WORD[4].W.B0.we_wire VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[4].W.B0.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[1].RAM8x32.WORD[4].W.B0.CGAND SLICE[1].RAM8x32.WORD[4].W.B0.SEL
+ SLICE[1].RAM8x32.WORD[0].W.B0.WE VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[4].W.B0.we_wire sky130_fd_sc_hd__and2_1
XSLICE[1].RAM8x32.WORD[4].W.B0.CLKINV SLICE[1].RAM8x32.WORD[4].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[4].W.B0.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[4].W.B0.SELINV SLICE[1].RAM8x32.WORD[4].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[4].W.B0.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[4].W.B1.BIT[0].LATCH SLICE[0].RAM8x32.Di[8]
+ SLICE[1].RAM8x32.WORD[4].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[4].W.B1.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[4].W.B1.BIT[0].OBUF
+ SLICE[1].RAM8x32.WORD[4].W.B1.q_wire[0] SLICE[1].RAM8x32.WORD[4].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[8] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[4].W.B1.BIT[1].LATCH SLICE[0].RAM8x32.Di[9]
+ SLICE[1].RAM8x32.WORD[4].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[4].W.B1.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[4].W.B1.BIT[1].OBUF
+ SLICE[1].RAM8x32.WORD[4].W.B1.q_wire[1] SLICE[1].RAM8x32.WORD[4].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[9] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[4].W.B1.BIT[2].LATCH SLICE[0].RAM8x32.Di[10]
+ SLICE[1].RAM8x32.WORD[4].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[4].W.B1.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[4].W.B1.BIT[2].OBUF
+ SLICE[1].RAM8x32.WORD[4].W.B1.q_wire[2] SLICE[1].RAM8x32.WORD[4].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[10] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[4].W.B1.BIT[3].LATCH SLICE[0].RAM8x32.Di[11]
+ SLICE[1].RAM8x32.WORD[4].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[4].W.B1.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[4].W.B1.BIT[3].OBUF
+ SLICE[1].RAM8x32.WORD[4].W.B1.q_wire[3] SLICE[1].RAM8x32.WORD[4].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[11] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[4].W.B1.BIT[4].LATCH SLICE[0].RAM8x32.Di[12]
+ SLICE[1].RAM8x32.WORD[4].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[4].W.B1.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[4].W.B1.BIT[4].OBUF
+ SLICE[1].RAM8x32.WORD[4].W.B1.q_wire[4] SLICE[1].RAM8x32.WORD[4].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[12] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[4].W.B1.BIT[5].LATCH SLICE[0].RAM8x32.Di[13]
+ SLICE[1].RAM8x32.WORD[4].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[4].W.B1.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[4].W.B1.BIT[5].OBUF
+ SLICE[1].RAM8x32.WORD[4].W.B1.q_wire[5] SLICE[1].RAM8x32.WORD[4].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[13] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[4].W.B1.BIT[6].LATCH SLICE[0].RAM8x32.Di[14]
+ SLICE[1].RAM8x32.WORD[4].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[4].W.B1.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[4].W.B1.BIT[6].OBUF
+ SLICE[1].RAM8x32.WORD[4].W.B1.q_wire[6] SLICE[1].RAM8x32.WORD[4].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[14] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[4].W.B1.BIT[7].LATCH SLICE[0].RAM8x32.Di[15]
+ SLICE[1].RAM8x32.WORD[4].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[4].W.B1.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[4].W.B1.BIT[7].OBUF
+ SLICE[1].RAM8x32.WORD[4].W.B1.q_wire[7] SLICE[1].RAM8x32.WORD[4].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[15] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[4].W.B1.CG SLICE[1].RAM8x32.WORD[4].W.B1.CLK_B
+ SLICE[1].RAM8x32.WORD[4].W.B1.we_wire VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[4].W.B1.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[1].RAM8x32.WORD[4].W.B1.CGAND SLICE[1].RAM8x32.WORD[4].W.B0.SEL
+ SLICE[1].RAM8x32.WORD[0].W.B1.WE VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[4].W.B1.we_wire sky130_fd_sc_hd__and2_1
XSLICE[1].RAM8x32.WORD[4].W.B1.CLKINV SLICE[1].RAM8x32.WORD[4].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[4].W.B1.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[4].W.B1.SELINV SLICE[1].RAM8x32.WORD[4].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[4].W.B1.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[4].W.B2.BIT[0].LATCH SLICE[0].RAM8x32.Di[16]
+ SLICE[1].RAM8x32.WORD[4].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[4].W.B2.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[4].W.B2.BIT[0].OBUF
+ SLICE[1].RAM8x32.WORD[4].W.B2.q_wire[0] SLICE[1].RAM8x32.WORD[4].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[16] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[4].W.B2.BIT[1].LATCH SLICE[0].RAM8x32.Di[17]
+ SLICE[1].RAM8x32.WORD[4].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[4].W.B2.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[4].W.B2.BIT[1].OBUF
+ SLICE[1].RAM8x32.WORD[4].W.B2.q_wire[1] SLICE[1].RAM8x32.WORD[4].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[17] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[4].W.B2.BIT[2].LATCH SLICE[0].RAM8x32.Di[18]
+ SLICE[1].RAM8x32.WORD[4].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[4].W.B2.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[4].W.B2.BIT[2].OBUF
+ SLICE[1].RAM8x32.WORD[4].W.B2.q_wire[2] SLICE[1].RAM8x32.WORD[4].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[18] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[4].W.B2.BIT[3].LATCH SLICE[0].RAM8x32.Di[19]
+ SLICE[1].RAM8x32.WORD[4].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[4].W.B2.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[4].W.B2.BIT[3].OBUF
+ SLICE[1].RAM8x32.WORD[4].W.B2.q_wire[3] SLICE[1].RAM8x32.WORD[4].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[19] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[4].W.B2.BIT[4].LATCH SLICE[0].RAM8x32.Di[20]
+ SLICE[1].RAM8x32.WORD[4].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[4].W.B2.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[4].W.B2.BIT[4].OBUF
+ SLICE[1].RAM8x32.WORD[4].W.B2.q_wire[4] SLICE[1].RAM8x32.WORD[4].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[20] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[4].W.B2.BIT[5].LATCH SLICE[0].RAM8x32.Di[21]
+ SLICE[1].RAM8x32.WORD[4].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[4].W.B2.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[4].W.B2.BIT[5].OBUF
+ SLICE[1].RAM8x32.WORD[4].W.B2.q_wire[5] SLICE[1].RAM8x32.WORD[4].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[21] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[4].W.B2.BIT[6].LATCH SLICE[0].RAM8x32.Di[22]
+ SLICE[1].RAM8x32.WORD[4].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[4].W.B2.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[4].W.B2.BIT[6].OBUF
+ SLICE[1].RAM8x32.WORD[4].W.B2.q_wire[6] SLICE[1].RAM8x32.WORD[4].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[22] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[4].W.B2.BIT[7].LATCH SLICE[0].RAM8x32.Di[23]
+ SLICE[1].RAM8x32.WORD[4].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[4].W.B2.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[4].W.B2.BIT[7].OBUF
+ SLICE[1].RAM8x32.WORD[4].W.B2.q_wire[7] SLICE[1].RAM8x32.WORD[4].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[23] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[4].W.B2.CG SLICE[1].RAM8x32.WORD[4].W.B2.CLK_B
+ SLICE[1].RAM8x32.WORD[4].W.B2.we_wire VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[4].W.B2.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[1].RAM8x32.WORD[4].W.B2.CGAND SLICE[1].RAM8x32.WORD[4].W.B0.SEL
+ SLICE[1].RAM8x32.WORD[0].W.B2.WE VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[4].W.B2.we_wire sky130_fd_sc_hd__and2_1
XSLICE[1].RAM8x32.WORD[4].W.B2.CLKINV SLICE[1].RAM8x32.WORD[4].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[4].W.B2.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[4].W.B2.SELINV SLICE[1].RAM8x32.WORD[4].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[4].W.B2.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[4].W.B3.BIT[0].LATCH SLICE[0].RAM8x32.Di[24]
+ SLICE[1].RAM8x32.WORD[4].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[4].W.B3.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[4].W.B3.BIT[0].OBUF
+ SLICE[1].RAM8x32.WORD[4].W.B3.q_wire[0] SLICE[1].RAM8x32.WORD[4].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[24] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[4].W.B3.BIT[1].LATCH SLICE[0].RAM8x32.Di[25]
+ SLICE[1].RAM8x32.WORD[4].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[4].W.B3.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[4].W.B3.BIT[1].OBUF
+ SLICE[1].RAM8x32.WORD[4].W.B3.q_wire[1] SLICE[1].RAM8x32.WORD[4].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[25] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[4].W.B3.BIT[2].LATCH SLICE[0].RAM8x32.Di[26]
+ SLICE[1].RAM8x32.WORD[4].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[4].W.B3.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[4].W.B3.BIT[2].OBUF
+ SLICE[1].RAM8x32.WORD[4].W.B3.q_wire[2] SLICE[1].RAM8x32.WORD[4].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[26] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[4].W.B3.BIT[3].LATCH SLICE[0].RAM8x32.Di[27]
+ SLICE[1].RAM8x32.WORD[4].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[4].W.B3.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[4].W.B3.BIT[3].OBUF
+ SLICE[1].RAM8x32.WORD[4].W.B3.q_wire[3] SLICE[1].RAM8x32.WORD[4].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[27] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[4].W.B3.BIT[4].LATCH SLICE[0].RAM8x32.Di[28]
+ SLICE[1].RAM8x32.WORD[4].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[4].W.B3.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[4].W.B3.BIT[4].OBUF
+ SLICE[1].RAM8x32.WORD[4].W.B3.q_wire[4] SLICE[1].RAM8x32.WORD[4].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[28] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[4].W.B3.BIT[5].LATCH SLICE[0].RAM8x32.Di[29]
+ SLICE[1].RAM8x32.WORD[4].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[4].W.B3.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[4].W.B3.BIT[5].OBUF
+ SLICE[1].RAM8x32.WORD[4].W.B3.q_wire[5] SLICE[1].RAM8x32.WORD[4].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[29] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[4].W.B3.BIT[6].LATCH SLICE[0].RAM8x32.Di[30]
+ SLICE[1].RAM8x32.WORD[4].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[4].W.B3.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[4].W.B3.BIT[6].OBUF
+ SLICE[1].RAM8x32.WORD[4].W.B3.q_wire[6] SLICE[1].RAM8x32.WORD[4].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[30] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[4].W.B3.BIT[7].LATCH SLICE[0].RAM8x32.Di[31]
+ SLICE[1].RAM8x32.WORD[4].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[4].W.B3.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[4].W.B3.BIT[7].OBUF
+ SLICE[1].RAM8x32.WORD[4].W.B3.q_wire[7] SLICE[1].RAM8x32.WORD[4].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[31] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[4].W.B3.CG SLICE[1].RAM8x32.WORD[4].W.B3.CLK_B
+ SLICE[1].RAM8x32.WORD[4].W.B3.we_wire VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[4].W.B3.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[1].RAM8x32.WORD[4].W.B3.CGAND SLICE[1].RAM8x32.WORD[4].W.B0.SEL
+ SLICE[1].RAM8x32.WORD[0].W.B3.WE VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[4].W.B3.we_wire sky130_fd_sc_hd__and2_1
XSLICE[1].RAM8x32.WORD[4].W.B3.CLKINV SLICE[1].RAM8x32.WORD[4].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[4].W.B3.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[4].W.B3.SELINV SLICE[1].RAM8x32.WORD[4].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[4].W.B3.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[4].W.CLKBUF SLICE[1].RAM8x32.CLK_buf VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[4].W.B0.CLK sky130_fd_sc_hd__clkbuf_1
XSLICE[1].RAM8x32.WORD[4].W.SELBUF SLICE[1].RAM8x32.WORD[4].W.SEL VGND VGND
+ VPWR VPWR SLICE[1].RAM8x32.WORD[4].W.B0.SEL sky130_fd_sc_hd__clkbuf_2
XSLICE[1].RAM8x32.WORD[5].W.B0.BIT[0].LATCH SLICE[0].RAM8x32.Di[0]
+ SLICE[1].RAM8x32.WORD[5].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[5].W.B0.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[5].W.B0.BIT[0].OBUF
+ SLICE[1].RAM8x32.WORD[5].W.B0.q_wire[0] SLICE[1].RAM8x32.WORD[5].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[0] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[5].W.B0.BIT[1].LATCH SLICE[0].RAM8x32.Di[1]
+ SLICE[1].RAM8x32.WORD[5].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[5].W.B0.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[5].W.B0.BIT[1].OBUF
+ SLICE[1].RAM8x32.WORD[5].W.B0.q_wire[1] SLICE[1].RAM8x32.WORD[5].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[1] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[5].W.B0.BIT[2].LATCH SLICE[0].RAM8x32.Di[2]
+ SLICE[1].RAM8x32.WORD[5].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[5].W.B0.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[5].W.B0.BIT[2].OBUF
+ SLICE[1].RAM8x32.WORD[5].W.B0.q_wire[2] SLICE[1].RAM8x32.WORD[5].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[2] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[5].W.B0.BIT[3].LATCH SLICE[0].RAM8x32.Di[3]
+ SLICE[1].RAM8x32.WORD[5].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[5].W.B0.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[5].W.B0.BIT[3].OBUF
+ SLICE[1].RAM8x32.WORD[5].W.B0.q_wire[3] SLICE[1].RAM8x32.WORD[5].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[3] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[5].W.B0.BIT[4].LATCH SLICE[0].RAM8x32.Di[4]
+ SLICE[1].RAM8x32.WORD[5].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[5].W.B0.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[5].W.B0.BIT[4].OBUF
+ SLICE[1].RAM8x32.WORD[5].W.B0.q_wire[4] SLICE[1].RAM8x32.WORD[5].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[4] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[5].W.B0.BIT[5].LATCH SLICE[0].RAM8x32.Di[5]
+ SLICE[1].RAM8x32.WORD[5].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[5].W.B0.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[5].W.B0.BIT[5].OBUF
+ SLICE[1].RAM8x32.WORD[5].W.B0.q_wire[5] SLICE[1].RAM8x32.WORD[5].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[5] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[5].W.B0.BIT[6].LATCH SLICE[0].RAM8x32.Di[6]
+ SLICE[1].RAM8x32.WORD[5].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[5].W.B0.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[5].W.B0.BIT[6].OBUF
+ SLICE[1].RAM8x32.WORD[5].W.B0.q_wire[6] SLICE[1].RAM8x32.WORD[5].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[6] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[5].W.B0.BIT[7].LATCH SLICE[0].RAM8x32.Di[7]
+ SLICE[1].RAM8x32.WORD[5].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[5].W.B0.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[5].W.B0.BIT[7].OBUF
+ SLICE[1].RAM8x32.WORD[5].W.B0.q_wire[7] SLICE[1].RAM8x32.WORD[5].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[7] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[5].W.B0.CG SLICE[1].RAM8x32.WORD[5].W.B0.CLK_B
+ SLICE[1].RAM8x32.WORD[5].W.B0.we_wire VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[5].W.B0.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[1].RAM8x32.WORD[5].W.B0.CGAND SLICE[1].RAM8x32.WORD[5].W.B0.SEL
+ SLICE[1].RAM8x32.WORD[0].W.B0.WE VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[5].W.B0.we_wire sky130_fd_sc_hd__and2_1
XSLICE[1].RAM8x32.WORD[5].W.B0.CLKINV SLICE[1].RAM8x32.WORD[5].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[5].W.B0.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[5].W.B0.SELINV SLICE[1].RAM8x32.WORD[5].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[5].W.B0.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[5].W.B1.BIT[0].LATCH SLICE[0].RAM8x32.Di[8]
+ SLICE[1].RAM8x32.WORD[5].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[5].W.B1.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[5].W.B1.BIT[0].OBUF
+ SLICE[1].RAM8x32.WORD[5].W.B1.q_wire[0] SLICE[1].RAM8x32.WORD[5].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[8] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[5].W.B1.BIT[1].LATCH SLICE[0].RAM8x32.Di[9]
+ SLICE[1].RAM8x32.WORD[5].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[5].W.B1.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[5].W.B1.BIT[1].OBUF
+ SLICE[1].RAM8x32.WORD[5].W.B1.q_wire[1] SLICE[1].RAM8x32.WORD[5].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[9] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[5].W.B1.BIT[2].LATCH SLICE[0].RAM8x32.Di[10]
+ SLICE[1].RAM8x32.WORD[5].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[5].W.B1.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[5].W.B1.BIT[2].OBUF
+ SLICE[1].RAM8x32.WORD[5].W.B1.q_wire[2] SLICE[1].RAM8x32.WORD[5].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[10] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[5].W.B1.BIT[3].LATCH SLICE[0].RAM8x32.Di[11]
+ SLICE[1].RAM8x32.WORD[5].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[5].W.B1.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[5].W.B1.BIT[3].OBUF
+ SLICE[1].RAM8x32.WORD[5].W.B1.q_wire[3] SLICE[1].RAM8x32.WORD[5].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[11] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[5].W.B1.BIT[4].LATCH SLICE[0].RAM8x32.Di[12]
+ SLICE[1].RAM8x32.WORD[5].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[5].W.B1.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[5].W.B1.BIT[4].OBUF
+ SLICE[1].RAM8x32.WORD[5].W.B1.q_wire[4] SLICE[1].RAM8x32.WORD[5].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[12] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[5].W.B1.BIT[5].LATCH SLICE[0].RAM8x32.Di[13]
+ SLICE[1].RAM8x32.WORD[5].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[5].W.B1.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[5].W.B1.BIT[5].OBUF
+ SLICE[1].RAM8x32.WORD[5].W.B1.q_wire[5] SLICE[1].RAM8x32.WORD[5].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[13] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[5].W.B1.BIT[6].LATCH SLICE[0].RAM8x32.Di[14]
+ SLICE[1].RAM8x32.WORD[5].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[5].W.B1.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[5].W.B1.BIT[6].OBUF
+ SLICE[1].RAM8x32.WORD[5].W.B1.q_wire[6] SLICE[1].RAM8x32.WORD[5].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[14] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[5].W.B1.BIT[7].LATCH SLICE[0].RAM8x32.Di[15]
+ SLICE[1].RAM8x32.WORD[5].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[5].W.B1.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[5].W.B1.BIT[7].OBUF
+ SLICE[1].RAM8x32.WORD[5].W.B1.q_wire[7] SLICE[1].RAM8x32.WORD[5].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[15] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[5].W.B1.CG SLICE[1].RAM8x32.WORD[5].W.B1.CLK_B
+ SLICE[1].RAM8x32.WORD[5].W.B1.we_wire VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[5].W.B1.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[1].RAM8x32.WORD[5].W.B1.CGAND SLICE[1].RAM8x32.WORD[5].W.B0.SEL
+ SLICE[1].RAM8x32.WORD[0].W.B1.WE VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[5].W.B1.we_wire sky130_fd_sc_hd__and2_1
XSLICE[1].RAM8x32.WORD[5].W.B1.CLKINV SLICE[1].RAM8x32.WORD[5].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[5].W.B1.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[5].W.B1.SELINV SLICE[1].RAM8x32.WORD[5].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[5].W.B1.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[5].W.B2.BIT[0].LATCH SLICE[0].RAM8x32.Di[16]
+ SLICE[1].RAM8x32.WORD[5].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[5].W.B2.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[5].W.B2.BIT[0].OBUF
+ SLICE[1].RAM8x32.WORD[5].W.B2.q_wire[0] SLICE[1].RAM8x32.WORD[5].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[16] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[5].W.B2.BIT[1].LATCH SLICE[0].RAM8x32.Di[17]
+ SLICE[1].RAM8x32.WORD[5].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[5].W.B2.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[5].W.B2.BIT[1].OBUF
+ SLICE[1].RAM8x32.WORD[5].W.B2.q_wire[1] SLICE[1].RAM8x32.WORD[5].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[17] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[5].W.B2.BIT[2].LATCH SLICE[0].RAM8x32.Di[18]
+ SLICE[1].RAM8x32.WORD[5].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[5].W.B2.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[5].W.B2.BIT[2].OBUF
+ SLICE[1].RAM8x32.WORD[5].W.B2.q_wire[2] SLICE[1].RAM8x32.WORD[5].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[18] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[5].W.B2.BIT[3].LATCH SLICE[0].RAM8x32.Di[19]
+ SLICE[1].RAM8x32.WORD[5].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[5].W.B2.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[5].W.B2.BIT[3].OBUF
+ SLICE[1].RAM8x32.WORD[5].W.B2.q_wire[3] SLICE[1].RAM8x32.WORD[5].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[19] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[5].W.B2.BIT[4].LATCH SLICE[0].RAM8x32.Di[20]
+ SLICE[1].RAM8x32.WORD[5].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[5].W.B2.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[5].W.B2.BIT[4].OBUF
+ SLICE[1].RAM8x32.WORD[5].W.B2.q_wire[4] SLICE[1].RAM8x32.WORD[5].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[20] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[5].W.B2.BIT[5].LATCH SLICE[0].RAM8x32.Di[21]
+ SLICE[1].RAM8x32.WORD[5].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[5].W.B2.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[5].W.B2.BIT[5].OBUF
+ SLICE[1].RAM8x32.WORD[5].W.B2.q_wire[5] SLICE[1].RAM8x32.WORD[5].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[21] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[5].W.B2.BIT[6].LATCH SLICE[0].RAM8x32.Di[22]
+ SLICE[1].RAM8x32.WORD[5].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[5].W.B2.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[5].W.B2.BIT[6].OBUF
+ SLICE[1].RAM8x32.WORD[5].W.B2.q_wire[6] SLICE[1].RAM8x32.WORD[5].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[22] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[5].W.B2.BIT[7].LATCH SLICE[0].RAM8x32.Di[23]
+ SLICE[1].RAM8x32.WORD[5].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[5].W.B2.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[5].W.B2.BIT[7].OBUF
+ SLICE[1].RAM8x32.WORD[5].W.B2.q_wire[7] SLICE[1].RAM8x32.WORD[5].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[23] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[5].W.B2.CG SLICE[1].RAM8x32.WORD[5].W.B2.CLK_B
+ SLICE[1].RAM8x32.WORD[5].W.B2.we_wire VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[5].W.B2.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[1].RAM8x32.WORD[5].W.B2.CGAND SLICE[1].RAM8x32.WORD[5].W.B0.SEL
+ SLICE[1].RAM8x32.WORD[0].W.B2.WE VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[5].W.B2.we_wire sky130_fd_sc_hd__and2_1
XSLICE[1].RAM8x32.WORD[5].W.B2.CLKINV SLICE[1].RAM8x32.WORD[5].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[5].W.B2.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[5].W.B2.SELINV SLICE[1].RAM8x32.WORD[5].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[5].W.B2.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[5].W.B3.BIT[0].LATCH SLICE[0].RAM8x32.Di[24]
+ SLICE[1].RAM8x32.WORD[5].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[5].W.B3.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[5].W.B3.BIT[0].OBUF
+ SLICE[1].RAM8x32.WORD[5].W.B3.q_wire[0] SLICE[1].RAM8x32.WORD[5].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[24] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[5].W.B3.BIT[1].LATCH SLICE[0].RAM8x32.Di[25]
+ SLICE[1].RAM8x32.WORD[5].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[5].W.B3.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[5].W.B3.BIT[1].OBUF
+ SLICE[1].RAM8x32.WORD[5].W.B3.q_wire[1] SLICE[1].RAM8x32.WORD[5].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[25] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[5].W.B3.BIT[2].LATCH SLICE[0].RAM8x32.Di[26]
+ SLICE[1].RAM8x32.WORD[5].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[5].W.B3.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[5].W.B3.BIT[2].OBUF
+ SLICE[1].RAM8x32.WORD[5].W.B3.q_wire[2] SLICE[1].RAM8x32.WORD[5].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[26] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[5].W.B3.BIT[3].LATCH SLICE[0].RAM8x32.Di[27]
+ SLICE[1].RAM8x32.WORD[5].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[5].W.B3.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[5].W.B3.BIT[3].OBUF
+ SLICE[1].RAM8x32.WORD[5].W.B3.q_wire[3] SLICE[1].RAM8x32.WORD[5].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[27] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[5].W.B3.BIT[4].LATCH SLICE[0].RAM8x32.Di[28]
+ SLICE[1].RAM8x32.WORD[5].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[5].W.B3.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[5].W.B3.BIT[4].OBUF
+ SLICE[1].RAM8x32.WORD[5].W.B3.q_wire[4] SLICE[1].RAM8x32.WORD[5].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[28] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[5].W.B3.BIT[5].LATCH SLICE[0].RAM8x32.Di[29]
+ SLICE[1].RAM8x32.WORD[5].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[5].W.B3.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[5].W.B3.BIT[5].OBUF
+ SLICE[1].RAM8x32.WORD[5].W.B3.q_wire[5] SLICE[1].RAM8x32.WORD[5].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[29] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[5].W.B3.BIT[6].LATCH SLICE[0].RAM8x32.Di[30]
+ SLICE[1].RAM8x32.WORD[5].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[5].W.B3.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[5].W.B3.BIT[6].OBUF
+ SLICE[1].RAM8x32.WORD[5].W.B3.q_wire[6] SLICE[1].RAM8x32.WORD[5].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[30] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[5].W.B3.BIT[7].LATCH SLICE[0].RAM8x32.Di[31]
+ SLICE[1].RAM8x32.WORD[5].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[5].W.B3.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[5].W.B3.BIT[7].OBUF
+ SLICE[1].RAM8x32.WORD[5].W.B3.q_wire[7] SLICE[1].RAM8x32.WORD[5].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[31] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[5].W.B3.CG SLICE[1].RAM8x32.WORD[5].W.B3.CLK_B
+ SLICE[1].RAM8x32.WORD[5].W.B3.we_wire VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[5].W.B3.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[1].RAM8x32.WORD[5].W.B3.CGAND SLICE[1].RAM8x32.WORD[5].W.B0.SEL
+ SLICE[1].RAM8x32.WORD[0].W.B3.WE VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[5].W.B3.we_wire sky130_fd_sc_hd__and2_1
XSLICE[1].RAM8x32.WORD[5].W.B3.CLKINV SLICE[1].RAM8x32.WORD[5].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[5].W.B3.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[5].W.B3.SELINV SLICE[1].RAM8x32.WORD[5].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[5].W.B3.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[5].W.CLKBUF SLICE[1].RAM8x32.CLK_buf VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[5].W.B0.CLK sky130_fd_sc_hd__clkbuf_1
XSLICE[1].RAM8x32.WORD[5].W.SELBUF SLICE[1].RAM8x32.WORD[5].W.SEL VGND VGND
+ VPWR VPWR SLICE[1].RAM8x32.WORD[5].W.B0.SEL sky130_fd_sc_hd__clkbuf_2
XSLICE[1].RAM8x32.WORD[6].W.B0.BIT[0].LATCH SLICE[0].RAM8x32.Di[0]
+ SLICE[1].RAM8x32.WORD[6].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[6].W.B0.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[6].W.B0.BIT[0].OBUF
+ SLICE[1].RAM8x32.WORD[6].W.B0.q_wire[0] SLICE[1].RAM8x32.WORD[6].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[0] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[6].W.B0.BIT[1].LATCH SLICE[0].RAM8x32.Di[1]
+ SLICE[1].RAM8x32.WORD[6].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[6].W.B0.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[6].W.B0.BIT[1].OBUF
+ SLICE[1].RAM8x32.WORD[6].W.B0.q_wire[1] SLICE[1].RAM8x32.WORD[6].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[1] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[6].W.B0.BIT[2].LATCH SLICE[0].RAM8x32.Di[2]
+ SLICE[1].RAM8x32.WORD[6].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[6].W.B0.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[6].W.B0.BIT[2].OBUF
+ SLICE[1].RAM8x32.WORD[6].W.B0.q_wire[2] SLICE[1].RAM8x32.WORD[6].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[2] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[6].W.B0.BIT[3].LATCH SLICE[0].RAM8x32.Di[3]
+ SLICE[1].RAM8x32.WORD[6].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[6].W.B0.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[6].W.B0.BIT[3].OBUF
+ SLICE[1].RAM8x32.WORD[6].W.B0.q_wire[3] SLICE[1].RAM8x32.WORD[6].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[3] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[6].W.B0.BIT[4].LATCH SLICE[0].RAM8x32.Di[4]
+ SLICE[1].RAM8x32.WORD[6].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[6].W.B0.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[6].W.B0.BIT[4].OBUF
+ SLICE[1].RAM8x32.WORD[6].W.B0.q_wire[4] SLICE[1].RAM8x32.WORD[6].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[4] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[6].W.B0.BIT[5].LATCH SLICE[0].RAM8x32.Di[5]
+ SLICE[1].RAM8x32.WORD[6].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[6].W.B0.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[6].W.B0.BIT[5].OBUF
+ SLICE[1].RAM8x32.WORD[6].W.B0.q_wire[5] SLICE[1].RAM8x32.WORD[6].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[5] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[6].W.B0.BIT[6].LATCH SLICE[0].RAM8x32.Di[6]
+ SLICE[1].RAM8x32.WORD[6].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[6].W.B0.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[6].W.B0.BIT[6].OBUF
+ SLICE[1].RAM8x32.WORD[6].W.B0.q_wire[6] SLICE[1].RAM8x32.WORD[6].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[6] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[6].W.B0.BIT[7].LATCH SLICE[0].RAM8x32.Di[7]
+ SLICE[1].RAM8x32.WORD[6].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[6].W.B0.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[6].W.B0.BIT[7].OBUF
+ SLICE[1].RAM8x32.WORD[6].W.B0.q_wire[7] SLICE[1].RAM8x32.WORD[6].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[7] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[6].W.B0.CG SLICE[1].RAM8x32.WORD[6].W.B0.CLK_B
+ SLICE[1].RAM8x32.WORD[6].W.B0.we_wire VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[6].W.B0.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[1].RAM8x32.WORD[6].W.B0.CGAND SLICE[1].RAM8x32.WORD[6].W.B0.SEL
+ SLICE[1].RAM8x32.WORD[0].W.B0.WE VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[6].W.B0.we_wire sky130_fd_sc_hd__and2_1
XSLICE[1].RAM8x32.WORD[6].W.B0.CLKINV SLICE[1].RAM8x32.WORD[6].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[6].W.B0.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[6].W.B0.SELINV SLICE[1].RAM8x32.WORD[6].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[6].W.B0.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[6].W.B1.BIT[0].LATCH SLICE[0].RAM8x32.Di[8]
+ SLICE[1].RAM8x32.WORD[6].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[6].W.B1.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[6].W.B1.BIT[0].OBUF
+ SLICE[1].RAM8x32.WORD[6].W.B1.q_wire[0] SLICE[1].RAM8x32.WORD[6].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[8] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[6].W.B1.BIT[1].LATCH SLICE[0].RAM8x32.Di[9]
+ SLICE[1].RAM8x32.WORD[6].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[6].W.B1.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[6].W.B1.BIT[1].OBUF
+ SLICE[1].RAM8x32.WORD[6].W.B1.q_wire[1] SLICE[1].RAM8x32.WORD[6].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[9] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[6].W.B1.BIT[2].LATCH SLICE[0].RAM8x32.Di[10]
+ SLICE[1].RAM8x32.WORD[6].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[6].W.B1.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[6].W.B1.BIT[2].OBUF
+ SLICE[1].RAM8x32.WORD[6].W.B1.q_wire[2] SLICE[1].RAM8x32.WORD[6].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[10] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[6].W.B1.BIT[3].LATCH SLICE[0].RAM8x32.Di[11]
+ SLICE[1].RAM8x32.WORD[6].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[6].W.B1.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[6].W.B1.BIT[3].OBUF
+ SLICE[1].RAM8x32.WORD[6].W.B1.q_wire[3] SLICE[1].RAM8x32.WORD[6].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[11] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[6].W.B1.BIT[4].LATCH SLICE[0].RAM8x32.Di[12]
+ SLICE[1].RAM8x32.WORD[6].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[6].W.B1.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[6].W.B1.BIT[4].OBUF
+ SLICE[1].RAM8x32.WORD[6].W.B1.q_wire[4] SLICE[1].RAM8x32.WORD[6].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[12] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[6].W.B1.BIT[5].LATCH SLICE[0].RAM8x32.Di[13]
+ SLICE[1].RAM8x32.WORD[6].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[6].W.B1.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[6].W.B1.BIT[5].OBUF
+ SLICE[1].RAM8x32.WORD[6].W.B1.q_wire[5] SLICE[1].RAM8x32.WORD[6].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[13] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[6].W.B1.BIT[6].LATCH SLICE[0].RAM8x32.Di[14]
+ SLICE[1].RAM8x32.WORD[6].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[6].W.B1.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[6].W.B1.BIT[6].OBUF
+ SLICE[1].RAM8x32.WORD[6].W.B1.q_wire[6] SLICE[1].RAM8x32.WORD[6].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[14] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[6].W.B1.BIT[7].LATCH SLICE[0].RAM8x32.Di[15]
+ SLICE[1].RAM8x32.WORD[6].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[6].W.B1.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[6].W.B1.BIT[7].OBUF
+ SLICE[1].RAM8x32.WORD[6].W.B1.q_wire[7] SLICE[1].RAM8x32.WORD[6].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[15] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[6].W.B1.CG SLICE[1].RAM8x32.WORD[6].W.B1.CLK_B
+ SLICE[1].RAM8x32.WORD[6].W.B1.we_wire VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[6].W.B1.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[1].RAM8x32.WORD[6].W.B1.CGAND SLICE[1].RAM8x32.WORD[6].W.B0.SEL
+ SLICE[1].RAM8x32.WORD[0].W.B1.WE VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[6].W.B1.we_wire sky130_fd_sc_hd__and2_1
XSLICE[1].RAM8x32.WORD[6].W.B1.CLKINV SLICE[1].RAM8x32.WORD[6].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[6].W.B1.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[6].W.B1.SELINV SLICE[1].RAM8x32.WORD[6].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[6].W.B1.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[6].W.B2.BIT[0].LATCH SLICE[0].RAM8x32.Di[16]
+ SLICE[1].RAM8x32.WORD[6].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[6].W.B2.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[6].W.B2.BIT[0].OBUF
+ SLICE[1].RAM8x32.WORD[6].W.B2.q_wire[0] SLICE[1].RAM8x32.WORD[6].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[16] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[6].W.B2.BIT[1].LATCH SLICE[0].RAM8x32.Di[17]
+ SLICE[1].RAM8x32.WORD[6].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[6].W.B2.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[6].W.B2.BIT[1].OBUF
+ SLICE[1].RAM8x32.WORD[6].W.B2.q_wire[1] SLICE[1].RAM8x32.WORD[6].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[17] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[6].W.B2.BIT[2].LATCH SLICE[0].RAM8x32.Di[18]
+ SLICE[1].RAM8x32.WORD[6].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[6].W.B2.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[6].W.B2.BIT[2].OBUF
+ SLICE[1].RAM8x32.WORD[6].W.B2.q_wire[2] SLICE[1].RAM8x32.WORD[6].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[18] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[6].W.B2.BIT[3].LATCH SLICE[0].RAM8x32.Di[19]
+ SLICE[1].RAM8x32.WORD[6].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[6].W.B2.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[6].W.B2.BIT[3].OBUF
+ SLICE[1].RAM8x32.WORD[6].W.B2.q_wire[3] SLICE[1].RAM8x32.WORD[6].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[19] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[6].W.B2.BIT[4].LATCH SLICE[0].RAM8x32.Di[20]
+ SLICE[1].RAM8x32.WORD[6].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[6].W.B2.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[6].W.B2.BIT[4].OBUF
+ SLICE[1].RAM8x32.WORD[6].W.B2.q_wire[4] SLICE[1].RAM8x32.WORD[6].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[20] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[6].W.B2.BIT[5].LATCH SLICE[0].RAM8x32.Di[21]
+ SLICE[1].RAM8x32.WORD[6].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[6].W.B2.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[6].W.B2.BIT[5].OBUF
+ SLICE[1].RAM8x32.WORD[6].W.B2.q_wire[5] SLICE[1].RAM8x32.WORD[6].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[21] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[6].W.B2.BIT[6].LATCH SLICE[0].RAM8x32.Di[22]
+ SLICE[1].RAM8x32.WORD[6].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[6].W.B2.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[6].W.B2.BIT[6].OBUF
+ SLICE[1].RAM8x32.WORD[6].W.B2.q_wire[6] SLICE[1].RAM8x32.WORD[6].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[22] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[6].W.B2.BIT[7].LATCH SLICE[0].RAM8x32.Di[23]
+ SLICE[1].RAM8x32.WORD[6].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[6].W.B2.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[6].W.B2.BIT[7].OBUF
+ SLICE[1].RAM8x32.WORD[6].W.B2.q_wire[7] SLICE[1].RAM8x32.WORD[6].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[23] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[6].W.B2.CG SLICE[1].RAM8x32.WORD[6].W.B2.CLK_B
+ SLICE[1].RAM8x32.WORD[6].W.B2.we_wire VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[6].W.B2.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[1].RAM8x32.WORD[6].W.B2.CGAND SLICE[1].RAM8x32.WORD[6].W.B0.SEL
+ SLICE[1].RAM8x32.WORD[0].W.B2.WE VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[6].W.B2.we_wire sky130_fd_sc_hd__and2_1
XSLICE[1].RAM8x32.WORD[6].W.B2.CLKINV SLICE[1].RAM8x32.WORD[6].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[6].W.B2.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[6].W.B2.SELINV SLICE[1].RAM8x32.WORD[6].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[6].W.B2.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[6].W.B3.BIT[0].LATCH SLICE[0].RAM8x32.Di[24]
+ SLICE[1].RAM8x32.WORD[6].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[6].W.B3.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[6].W.B3.BIT[0].OBUF
+ SLICE[1].RAM8x32.WORD[6].W.B3.q_wire[0] SLICE[1].RAM8x32.WORD[6].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[24] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[6].W.B3.BIT[1].LATCH SLICE[0].RAM8x32.Di[25]
+ SLICE[1].RAM8x32.WORD[6].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[6].W.B3.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[6].W.B3.BIT[1].OBUF
+ SLICE[1].RAM8x32.WORD[6].W.B3.q_wire[1] SLICE[1].RAM8x32.WORD[6].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[25] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[6].W.B3.BIT[2].LATCH SLICE[0].RAM8x32.Di[26]
+ SLICE[1].RAM8x32.WORD[6].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[6].W.B3.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[6].W.B3.BIT[2].OBUF
+ SLICE[1].RAM8x32.WORD[6].W.B3.q_wire[2] SLICE[1].RAM8x32.WORD[6].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[26] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[6].W.B3.BIT[3].LATCH SLICE[0].RAM8x32.Di[27]
+ SLICE[1].RAM8x32.WORD[6].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[6].W.B3.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[6].W.B3.BIT[3].OBUF
+ SLICE[1].RAM8x32.WORD[6].W.B3.q_wire[3] SLICE[1].RAM8x32.WORD[6].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[27] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[6].W.B3.BIT[4].LATCH SLICE[0].RAM8x32.Di[28]
+ SLICE[1].RAM8x32.WORD[6].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[6].W.B3.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[6].W.B3.BIT[4].OBUF
+ SLICE[1].RAM8x32.WORD[6].W.B3.q_wire[4] SLICE[1].RAM8x32.WORD[6].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[28] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[6].W.B3.BIT[5].LATCH SLICE[0].RAM8x32.Di[29]
+ SLICE[1].RAM8x32.WORD[6].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[6].W.B3.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[6].W.B3.BIT[5].OBUF
+ SLICE[1].RAM8x32.WORD[6].W.B3.q_wire[5] SLICE[1].RAM8x32.WORD[6].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[29] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[6].W.B3.BIT[6].LATCH SLICE[0].RAM8x32.Di[30]
+ SLICE[1].RAM8x32.WORD[6].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[6].W.B3.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[6].W.B3.BIT[6].OBUF
+ SLICE[1].RAM8x32.WORD[6].W.B3.q_wire[6] SLICE[1].RAM8x32.WORD[6].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[30] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[6].W.B3.BIT[7].LATCH SLICE[0].RAM8x32.Di[31]
+ SLICE[1].RAM8x32.WORD[6].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[6].W.B3.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[6].W.B3.BIT[7].OBUF
+ SLICE[1].RAM8x32.WORD[6].W.B3.q_wire[7] SLICE[1].RAM8x32.WORD[6].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[31] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[6].W.B3.CG SLICE[1].RAM8x32.WORD[6].W.B3.CLK_B
+ SLICE[1].RAM8x32.WORD[6].W.B3.we_wire VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[6].W.B3.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[1].RAM8x32.WORD[6].W.B3.CGAND SLICE[1].RAM8x32.WORD[6].W.B0.SEL
+ SLICE[1].RAM8x32.WORD[0].W.B3.WE VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[6].W.B3.we_wire sky130_fd_sc_hd__and2_1
XSLICE[1].RAM8x32.WORD[6].W.B3.CLKINV SLICE[1].RAM8x32.WORD[6].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[6].W.B3.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[6].W.B3.SELINV SLICE[1].RAM8x32.WORD[6].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[6].W.B3.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[6].W.CLKBUF SLICE[1].RAM8x32.CLK_buf VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[6].W.B0.CLK sky130_fd_sc_hd__clkbuf_1
XSLICE[1].RAM8x32.WORD[6].W.SELBUF SLICE[1].RAM8x32.WORD[6].W.SEL VGND VGND
+ VPWR VPWR SLICE[1].RAM8x32.WORD[6].W.B0.SEL sky130_fd_sc_hd__clkbuf_2
XSLICE[1].RAM8x32.WORD[7].W.B0.BIT[0].LATCH SLICE[0].RAM8x32.Di[0]
+ SLICE[1].RAM8x32.WORD[7].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[7].W.B0.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[7].W.B0.BIT[0].OBUF
+ SLICE[1].RAM8x32.WORD[7].W.B0.q_wire[0] SLICE[1].RAM8x32.WORD[7].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[0] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[7].W.B0.BIT[1].LATCH SLICE[0].RAM8x32.Di[1]
+ SLICE[1].RAM8x32.WORD[7].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[7].W.B0.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[7].W.B0.BIT[1].OBUF
+ SLICE[1].RAM8x32.WORD[7].W.B0.q_wire[1] SLICE[1].RAM8x32.WORD[7].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[1] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[7].W.B0.BIT[2].LATCH SLICE[0].RAM8x32.Di[2]
+ SLICE[1].RAM8x32.WORD[7].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[7].W.B0.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[7].W.B0.BIT[2].OBUF
+ SLICE[1].RAM8x32.WORD[7].W.B0.q_wire[2] SLICE[1].RAM8x32.WORD[7].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[2] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[7].W.B0.BIT[3].LATCH SLICE[0].RAM8x32.Di[3]
+ SLICE[1].RAM8x32.WORD[7].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[7].W.B0.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[7].W.B0.BIT[3].OBUF
+ SLICE[1].RAM8x32.WORD[7].W.B0.q_wire[3] SLICE[1].RAM8x32.WORD[7].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[3] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[7].W.B0.BIT[4].LATCH SLICE[0].RAM8x32.Di[4]
+ SLICE[1].RAM8x32.WORD[7].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[7].W.B0.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[7].W.B0.BIT[4].OBUF
+ SLICE[1].RAM8x32.WORD[7].W.B0.q_wire[4] SLICE[1].RAM8x32.WORD[7].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[4] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[7].W.B0.BIT[5].LATCH SLICE[0].RAM8x32.Di[5]
+ SLICE[1].RAM8x32.WORD[7].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[7].W.B0.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[7].W.B0.BIT[5].OBUF
+ SLICE[1].RAM8x32.WORD[7].W.B0.q_wire[5] SLICE[1].RAM8x32.WORD[7].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[5] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[7].W.B0.BIT[6].LATCH SLICE[0].RAM8x32.Di[6]
+ SLICE[1].RAM8x32.WORD[7].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[7].W.B0.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[7].W.B0.BIT[6].OBUF
+ SLICE[1].RAM8x32.WORD[7].W.B0.q_wire[6] SLICE[1].RAM8x32.WORD[7].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[6] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[7].W.B0.BIT[7].LATCH SLICE[0].RAM8x32.Di[7]
+ SLICE[1].RAM8x32.WORD[7].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[7].W.B0.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[7].W.B0.BIT[7].OBUF
+ SLICE[1].RAM8x32.WORD[7].W.B0.q_wire[7] SLICE[1].RAM8x32.WORD[7].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[7] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[7].W.B0.CG SLICE[1].RAM8x32.WORD[7].W.B0.CLK_B
+ SLICE[1].RAM8x32.WORD[7].W.B0.we_wire VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[7].W.B0.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[1].RAM8x32.WORD[7].W.B0.CGAND SLICE[1].RAM8x32.WORD[7].W.B0.SEL
+ SLICE[1].RAM8x32.WORD[0].W.B0.WE VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[7].W.B0.we_wire sky130_fd_sc_hd__and2_1
XSLICE[1].RAM8x32.WORD[7].W.B0.CLKINV SLICE[1].RAM8x32.WORD[7].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[7].W.B0.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[7].W.B0.SELINV SLICE[1].RAM8x32.WORD[7].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[7].W.B0.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[7].W.B1.BIT[0].LATCH SLICE[0].RAM8x32.Di[8]
+ SLICE[1].RAM8x32.WORD[7].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[7].W.B1.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[7].W.B1.BIT[0].OBUF
+ SLICE[1].RAM8x32.WORD[7].W.B1.q_wire[0] SLICE[1].RAM8x32.WORD[7].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[8] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[7].W.B1.BIT[1].LATCH SLICE[0].RAM8x32.Di[9]
+ SLICE[1].RAM8x32.WORD[7].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[7].W.B1.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[7].W.B1.BIT[1].OBUF
+ SLICE[1].RAM8x32.WORD[7].W.B1.q_wire[1] SLICE[1].RAM8x32.WORD[7].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[9] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[7].W.B1.BIT[2].LATCH SLICE[0].RAM8x32.Di[10]
+ SLICE[1].RAM8x32.WORD[7].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[7].W.B1.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[7].W.B1.BIT[2].OBUF
+ SLICE[1].RAM8x32.WORD[7].W.B1.q_wire[2] SLICE[1].RAM8x32.WORD[7].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[10] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[7].W.B1.BIT[3].LATCH SLICE[0].RAM8x32.Di[11]
+ SLICE[1].RAM8x32.WORD[7].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[7].W.B1.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[7].W.B1.BIT[3].OBUF
+ SLICE[1].RAM8x32.WORD[7].W.B1.q_wire[3] SLICE[1].RAM8x32.WORD[7].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[11] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[7].W.B1.BIT[4].LATCH SLICE[0].RAM8x32.Di[12]
+ SLICE[1].RAM8x32.WORD[7].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[7].W.B1.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[7].W.B1.BIT[4].OBUF
+ SLICE[1].RAM8x32.WORD[7].W.B1.q_wire[4] SLICE[1].RAM8x32.WORD[7].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[12] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[7].W.B1.BIT[5].LATCH SLICE[0].RAM8x32.Di[13]
+ SLICE[1].RAM8x32.WORD[7].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[7].W.B1.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[7].W.B1.BIT[5].OBUF
+ SLICE[1].RAM8x32.WORD[7].W.B1.q_wire[5] SLICE[1].RAM8x32.WORD[7].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[13] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[7].W.B1.BIT[6].LATCH SLICE[0].RAM8x32.Di[14]
+ SLICE[1].RAM8x32.WORD[7].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[7].W.B1.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[7].W.B1.BIT[6].OBUF
+ SLICE[1].RAM8x32.WORD[7].W.B1.q_wire[6] SLICE[1].RAM8x32.WORD[7].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[14] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[7].W.B1.BIT[7].LATCH SLICE[0].RAM8x32.Di[15]
+ SLICE[1].RAM8x32.WORD[7].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[7].W.B1.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[7].W.B1.BIT[7].OBUF
+ SLICE[1].RAM8x32.WORD[7].W.B1.q_wire[7] SLICE[1].RAM8x32.WORD[7].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[15] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[7].W.B1.CG SLICE[1].RAM8x32.WORD[7].W.B1.CLK_B
+ SLICE[1].RAM8x32.WORD[7].W.B1.we_wire VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[7].W.B1.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[1].RAM8x32.WORD[7].W.B1.CGAND SLICE[1].RAM8x32.WORD[7].W.B0.SEL
+ SLICE[1].RAM8x32.WORD[0].W.B1.WE VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[7].W.B1.we_wire sky130_fd_sc_hd__and2_1
XSLICE[1].RAM8x32.WORD[7].W.B1.CLKINV SLICE[1].RAM8x32.WORD[7].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[7].W.B1.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[7].W.B1.SELINV SLICE[1].RAM8x32.WORD[7].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[7].W.B1.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[7].W.B2.BIT[0].LATCH SLICE[0].RAM8x32.Di[16]
+ SLICE[1].RAM8x32.WORD[7].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[7].W.B2.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[7].W.B2.BIT[0].OBUF
+ SLICE[1].RAM8x32.WORD[7].W.B2.q_wire[0] SLICE[1].RAM8x32.WORD[7].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[16] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[7].W.B2.BIT[1].LATCH SLICE[0].RAM8x32.Di[17]
+ SLICE[1].RAM8x32.WORD[7].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[7].W.B2.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[7].W.B2.BIT[1].OBUF
+ SLICE[1].RAM8x32.WORD[7].W.B2.q_wire[1] SLICE[1].RAM8x32.WORD[7].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[17] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[7].W.B2.BIT[2].LATCH SLICE[0].RAM8x32.Di[18]
+ SLICE[1].RAM8x32.WORD[7].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[7].W.B2.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[7].W.B2.BIT[2].OBUF
+ SLICE[1].RAM8x32.WORD[7].W.B2.q_wire[2] SLICE[1].RAM8x32.WORD[7].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[18] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[7].W.B2.BIT[3].LATCH SLICE[0].RAM8x32.Di[19]
+ SLICE[1].RAM8x32.WORD[7].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[7].W.B2.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[7].W.B2.BIT[3].OBUF
+ SLICE[1].RAM8x32.WORD[7].W.B2.q_wire[3] SLICE[1].RAM8x32.WORD[7].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[19] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[7].W.B2.BIT[4].LATCH SLICE[0].RAM8x32.Di[20]
+ SLICE[1].RAM8x32.WORD[7].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[7].W.B2.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[7].W.B2.BIT[4].OBUF
+ SLICE[1].RAM8x32.WORD[7].W.B2.q_wire[4] SLICE[1].RAM8x32.WORD[7].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[20] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[7].W.B2.BIT[5].LATCH SLICE[0].RAM8x32.Di[21]
+ SLICE[1].RAM8x32.WORD[7].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[7].W.B2.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[7].W.B2.BIT[5].OBUF
+ SLICE[1].RAM8x32.WORD[7].W.B2.q_wire[5] SLICE[1].RAM8x32.WORD[7].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[21] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[7].W.B2.BIT[6].LATCH SLICE[0].RAM8x32.Di[22]
+ SLICE[1].RAM8x32.WORD[7].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[7].W.B2.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[7].W.B2.BIT[6].OBUF
+ SLICE[1].RAM8x32.WORD[7].W.B2.q_wire[6] SLICE[1].RAM8x32.WORD[7].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[22] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[7].W.B2.BIT[7].LATCH SLICE[0].RAM8x32.Di[23]
+ SLICE[1].RAM8x32.WORD[7].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[7].W.B2.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[7].W.B2.BIT[7].OBUF
+ SLICE[1].RAM8x32.WORD[7].W.B2.q_wire[7] SLICE[1].RAM8x32.WORD[7].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[23] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[7].W.B2.CG SLICE[1].RAM8x32.WORD[7].W.B2.CLK_B
+ SLICE[1].RAM8x32.WORD[7].W.B2.we_wire VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[7].W.B2.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[1].RAM8x32.WORD[7].W.B2.CGAND SLICE[1].RAM8x32.WORD[7].W.B0.SEL
+ SLICE[1].RAM8x32.WORD[0].W.B2.WE VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[7].W.B2.we_wire sky130_fd_sc_hd__and2_1
XSLICE[1].RAM8x32.WORD[7].W.B2.CLKINV SLICE[1].RAM8x32.WORD[7].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[7].W.B2.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[7].W.B2.SELINV SLICE[1].RAM8x32.WORD[7].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[7].W.B2.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[7].W.B3.BIT[0].LATCH SLICE[0].RAM8x32.Di[24]
+ SLICE[1].RAM8x32.WORD[7].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[7].W.B3.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[7].W.B3.BIT[0].OBUF
+ SLICE[1].RAM8x32.WORD[7].W.B3.q_wire[0] SLICE[1].RAM8x32.WORD[7].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[24] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[7].W.B3.BIT[1].LATCH SLICE[0].RAM8x32.Di[25]
+ SLICE[1].RAM8x32.WORD[7].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[7].W.B3.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[7].W.B3.BIT[1].OBUF
+ SLICE[1].RAM8x32.WORD[7].W.B3.q_wire[1] SLICE[1].RAM8x32.WORD[7].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[25] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[7].W.B3.BIT[2].LATCH SLICE[0].RAM8x32.Di[26]
+ SLICE[1].RAM8x32.WORD[7].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[7].W.B3.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[7].W.B3.BIT[2].OBUF
+ SLICE[1].RAM8x32.WORD[7].W.B3.q_wire[2] SLICE[1].RAM8x32.WORD[7].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[26] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[7].W.B3.BIT[3].LATCH SLICE[0].RAM8x32.Di[27]
+ SLICE[1].RAM8x32.WORD[7].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[7].W.B3.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[7].W.B3.BIT[3].OBUF
+ SLICE[1].RAM8x32.WORD[7].W.B3.q_wire[3] SLICE[1].RAM8x32.WORD[7].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[27] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[7].W.B3.BIT[4].LATCH SLICE[0].RAM8x32.Di[28]
+ SLICE[1].RAM8x32.WORD[7].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[7].W.B3.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[7].W.B3.BIT[4].OBUF
+ SLICE[1].RAM8x32.WORD[7].W.B3.q_wire[4] SLICE[1].RAM8x32.WORD[7].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[28] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[7].W.B3.BIT[5].LATCH SLICE[0].RAM8x32.Di[29]
+ SLICE[1].RAM8x32.WORD[7].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[7].W.B3.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[7].W.B3.BIT[5].OBUF
+ SLICE[1].RAM8x32.WORD[7].W.B3.q_wire[5] SLICE[1].RAM8x32.WORD[7].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[29] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[7].W.B3.BIT[6].LATCH SLICE[0].RAM8x32.Di[30]
+ SLICE[1].RAM8x32.WORD[7].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[7].W.B3.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[7].W.B3.BIT[6].OBUF
+ SLICE[1].RAM8x32.WORD[7].W.B3.q_wire[6] SLICE[1].RAM8x32.WORD[7].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[30] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[7].W.B3.BIT[7].LATCH SLICE[0].RAM8x32.Di[31]
+ SLICE[1].RAM8x32.WORD[7].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[7].W.B3.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[1].RAM8x32.WORD[7].W.B3.BIT[7].OBUF
+ SLICE[1].RAM8x32.WORD[7].W.B3.q_wire[7] SLICE[1].RAM8x32.WORD[7].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[31] sky130_fd_sc_hd__ebufn_2
XSLICE[1].RAM8x32.WORD[7].W.B3.CG SLICE[1].RAM8x32.WORD[7].W.B3.CLK_B
+ SLICE[1].RAM8x32.WORD[7].W.B3.we_wire VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[7].W.B3.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[1].RAM8x32.WORD[7].W.B3.CGAND SLICE[1].RAM8x32.WORD[7].W.B0.SEL
+ SLICE[1].RAM8x32.WORD[0].W.B3.WE VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[7].W.B3.we_wire sky130_fd_sc_hd__and2_1
XSLICE[1].RAM8x32.WORD[7].W.B3.CLKINV SLICE[1].RAM8x32.WORD[7].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[7].W.B3.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[7].W.B3.SELINV SLICE[1].RAM8x32.WORD[7].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[1].RAM8x32.WORD[7].W.B3.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[1].RAM8x32.WORD[7].W.CLKBUF SLICE[1].RAM8x32.CLK_buf VGND VGND VPWR VPWR
+ SLICE[1].RAM8x32.WORD[7].W.B0.CLK sky130_fd_sc_hd__clkbuf_1
XSLICE[1].RAM8x32.WORD[7].W.SELBUF SLICE[1].RAM8x32.WORD[7].W.SEL VGND VGND
+ VPWR VPWR SLICE[1].RAM8x32.WORD[7].W.B0.SEL sky130_fd_sc_hd__clkbuf_2
XSLICE[2].RAM8x32.CLKBUF SLICE[0].RAM8x32.CLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.CLK_buf sky130_fd_sc_hd__clkbuf_2
XSLICE[2].RAM8x32.DEC.ABUF[0] SLICE[0].RAM8x32.A[0] VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.DEC.A_buf[0] sky130_fd_sc_hd__clkbuf_2
XSLICE[2].RAM8x32.DEC.ABUF[1] SLICE[0].RAM8x32.A[1] VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.DEC.A_buf[1] sky130_fd_sc_hd__clkbuf_2
XSLICE[2].RAM8x32.DEC.ABUF[2] SLICE[0].RAM8x32.A[2] VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.DEC.A_buf[2] sky130_fd_sc_hd__clkbuf_2
XSLICE[2].RAM8x32.DEC.AND0 SLICE[2].RAM8x32.DEC.A_buf[0]
+ SLICE[2].RAM8x32.DEC.A_buf[1] SLICE[2].RAM8x32.DEC.A_buf[2]
+ SLICE[2].RAM8x32.DEC.EN_buf VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[0].W.SEL sky130_fd_sc_hd__nor4b_2
XSLICE[2].RAM8x32.DEC.AND1 SLICE[2].RAM8x32.DEC.A_buf[2]
+ SLICE[2].RAM8x32.DEC.A_buf[1] SLICE[2].RAM8x32.DEC.A_buf[0]
+ SLICE[2].RAM8x32.DEC.EN_buf VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[1].W.SEL sky130_fd_sc_hd__and4bb_2
XSLICE[2].RAM8x32.DEC.AND2 SLICE[2].RAM8x32.DEC.A_buf[2]
+ SLICE[2].RAM8x32.DEC.A_buf[0] SLICE[2].RAM8x32.DEC.A_buf[1]
+ SLICE[2].RAM8x32.DEC.EN_buf VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[2].W.SEL sky130_fd_sc_hd__and4bb_2
XSLICE[2].RAM8x32.DEC.AND3 SLICE[2].RAM8x32.DEC.A_buf[2]
+ SLICE[2].RAM8x32.DEC.A_buf[1] SLICE[2].RAM8x32.DEC.A_buf[0]
+ SLICE[2].RAM8x32.DEC.EN_buf VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[3].W.SEL sky130_fd_sc_hd__and4b_2
XSLICE[2].RAM8x32.DEC.AND4 SLICE[2].RAM8x32.DEC.A_buf[0]
+ SLICE[2].RAM8x32.DEC.A_buf[1] SLICE[2].RAM8x32.DEC.A_buf[2]
+ SLICE[2].RAM8x32.DEC.EN_buf VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[4].W.SEL sky130_fd_sc_hd__and4bb_2
XSLICE[2].RAM8x32.DEC.AND5 SLICE[2].RAM8x32.DEC.A_buf[1]
+ SLICE[2].RAM8x32.DEC.A_buf[0] SLICE[2].RAM8x32.DEC.A_buf[2]
+ SLICE[2].RAM8x32.DEC.EN_buf VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[5].W.SEL sky130_fd_sc_hd__and4b_2
XSLICE[2].RAM8x32.DEC.AND6 SLICE[2].RAM8x32.DEC.A_buf[0]
+ SLICE[2].RAM8x32.DEC.A_buf[1] SLICE[2].RAM8x32.DEC.A_buf[2]
+ SLICE[2].RAM8x32.DEC.EN_buf VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[6].W.SEL sky130_fd_sc_hd__and4b_2
XSLICE[2].RAM8x32.DEC.AND7 SLICE[2].RAM8x32.DEC.A_buf[0]
+ SLICE[2].RAM8x32.DEC.A_buf[1] SLICE[2].RAM8x32.DEC.A_buf[2]
+ SLICE[2].RAM8x32.DEC.EN_buf VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[7].W.SEL sky130_fd_sc_hd__and4_2
XSLICE[2].RAM8x32.DEC.ENBUF SLICE[2].RAM8x32.DEC.EN VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.DEC.EN_buf sky130_fd_sc_hd__clkbuf_2
XSLICE[2].RAM8x32.WEBUF[0] SLICE[0].RAM8x32.WE[0] VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[0].W.B0.WE sky130_fd_sc_hd__clkbuf_2
XSLICE[2].RAM8x32.WEBUF[1] SLICE[0].RAM8x32.WE[1] VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[0].W.B1.WE sky130_fd_sc_hd__clkbuf_2
XSLICE[2].RAM8x32.WEBUF[2] SLICE[0].RAM8x32.WE[2] VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[0].W.B2.WE sky130_fd_sc_hd__clkbuf_2
XSLICE[2].RAM8x32.WEBUF[3] SLICE[0].RAM8x32.WE[3] VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[0].W.B3.WE sky130_fd_sc_hd__clkbuf_2
XSLICE[2].RAM8x32.WORD[0].W.B0.BIT[0].LATCH SLICE[0].RAM8x32.Di[0]
+ SLICE[2].RAM8x32.WORD[0].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[0].W.B0.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[0].W.B0.BIT[0].OBUF
+ SLICE[2].RAM8x32.WORD[0].W.B0.q_wire[0] SLICE[2].RAM8x32.WORD[0].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[0] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[0].W.B0.BIT[1].LATCH SLICE[0].RAM8x32.Di[1]
+ SLICE[2].RAM8x32.WORD[0].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[0].W.B0.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[0].W.B0.BIT[1].OBUF
+ SLICE[2].RAM8x32.WORD[0].W.B0.q_wire[1] SLICE[2].RAM8x32.WORD[0].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[1] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[0].W.B0.BIT[2].LATCH SLICE[0].RAM8x32.Di[2]
+ SLICE[2].RAM8x32.WORD[0].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[0].W.B0.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[0].W.B0.BIT[2].OBUF
+ SLICE[2].RAM8x32.WORD[0].W.B0.q_wire[2] SLICE[2].RAM8x32.WORD[0].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[2] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[0].W.B0.BIT[3].LATCH SLICE[0].RAM8x32.Di[3]
+ SLICE[2].RAM8x32.WORD[0].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[0].W.B0.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[0].W.B0.BIT[3].OBUF
+ SLICE[2].RAM8x32.WORD[0].W.B0.q_wire[3] SLICE[2].RAM8x32.WORD[0].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[3] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[0].W.B0.BIT[4].LATCH SLICE[0].RAM8x32.Di[4]
+ SLICE[2].RAM8x32.WORD[0].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[0].W.B0.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[0].W.B0.BIT[4].OBUF
+ SLICE[2].RAM8x32.WORD[0].W.B0.q_wire[4] SLICE[2].RAM8x32.WORD[0].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[4] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[0].W.B0.BIT[5].LATCH SLICE[0].RAM8x32.Di[5]
+ SLICE[2].RAM8x32.WORD[0].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[0].W.B0.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[0].W.B0.BIT[5].OBUF
+ SLICE[2].RAM8x32.WORD[0].W.B0.q_wire[5] SLICE[2].RAM8x32.WORD[0].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[5] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[0].W.B0.BIT[6].LATCH SLICE[0].RAM8x32.Di[6]
+ SLICE[2].RAM8x32.WORD[0].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[0].W.B0.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[0].W.B0.BIT[6].OBUF
+ SLICE[2].RAM8x32.WORD[0].W.B0.q_wire[6] SLICE[2].RAM8x32.WORD[0].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[6] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[0].W.B0.BIT[7].LATCH SLICE[0].RAM8x32.Di[7]
+ SLICE[2].RAM8x32.WORD[0].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[0].W.B0.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[0].W.B0.BIT[7].OBUF
+ SLICE[2].RAM8x32.WORD[0].W.B0.q_wire[7] SLICE[2].RAM8x32.WORD[0].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[7] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[0].W.B0.CG SLICE[2].RAM8x32.WORD[0].W.B0.CLK_B
+ SLICE[2].RAM8x32.WORD[0].W.B0.we_wire VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[0].W.B0.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[2].RAM8x32.WORD[0].W.B0.CGAND SLICE[2].RAM8x32.WORD[0].W.B0.SEL
+ SLICE[2].RAM8x32.WORD[0].W.B0.WE VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[0].W.B0.we_wire sky130_fd_sc_hd__and2_1
XSLICE[2].RAM8x32.WORD[0].W.B0.CLKINV SLICE[2].RAM8x32.WORD[0].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[0].W.B0.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[0].W.B0.SELINV SLICE[2].RAM8x32.WORD[0].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[0].W.B0.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[0].W.B1.BIT[0].LATCH SLICE[0].RAM8x32.Di[8]
+ SLICE[2].RAM8x32.WORD[0].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[0].W.B1.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[0].W.B1.BIT[0].OBUF
+ SLICE[2].RAM8x32.WORD[0].W.B1.q_wire[0] SLICE[2].RAM8x32.WORD[0].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[8] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[0].W.B1.BIT[1].LATCH SLICE[0].RAM8x32.Di[9]
+ SLICE[2].RAM8x32.WORD[0].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[0].W.B1.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[0].W.B1.BIT[1].OBUF
+ SLICE[2].RAM8x32.WORD[0].W.B1.q_wire[1] SLICE[2].RAM8x32.WORD[0].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[9] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[0].W.B1.BIT[2].LATCH SLICE[0].RAM8x32.Di[10]
+ SLICE[2].RAM8x32.WORD[0].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[0].W.B1.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[0].W.B1.BIT[2].OBUF
+ SLICE[2].RAM8x32.WORD[0].W.B1.q_wire[2] SLICE[2].RAM8x32.WORD[0].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[10] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[0].W.B1.BIT[3].LATCH SLICE[0].RAM8x32.Di[11]
+ SLICE[2].RAM8x32.WORD[0].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[0].W.B1.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[0].W.B1.BIT[3].OBUF
+ SLICE[2].RAM8x32.WORD[0].W.B1.q_wire[3] SLICE[2].RAM8x32.WORD[0].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[11] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[0].W.B1.BIT[4].LATCH SLICE[0].RAM8x32.Di[12]
+ SLICE[2].RAM8x32.WORD[0].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[0].W.B1.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[0].W.B1.BIT[4].OBUF
+ SLICE[2].RAM8x32.WORD[0].W.B1.q_wire[4] SLICE[2].RAM8x32.WORD[0].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[12] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[0].W.B1.BIT[5].LATCH SLICE[0].RAM8x32.Di[13]
+ SLICE[2].RAM8x32.WORD[0].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[0].W.B1.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[0].W.B1.BIT[5].OBUF
+ SLICE[2].RAM8x32.WORD[0].W.B1.q_wire[5] SLICE[2].RAM8x32.WORD[0].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[13] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[0].W.B1.BIT[6].LATCH SLICE[0].RAM8x32.Di[14]
+ SLICE[2].RAM8x32.WORD[0].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[0].W.B1.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[0].W.B1.BIT[6].OBUF
+ SLICE[2].RAM8x32.WORD[0].W.B1.q_wire[6] SLICE[2].RAM8x32.WORD[0].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[14] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[0].W.B1.BIT[7].LATCH SLICE[0].RAM8x32.Di[15]
+ SLICE[2].RAM8x32.WORD[0].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[0].W.B1.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[0].W.B1.BIT[7].OBUF
+ SLICE[2].RAM8x32.WORD[0].W.B1.q_wire[7] SLICE[2].RAM8x32.WORD[0].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[15] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[0].W.B1.CG SLICE[2].RAM8x32.WORD[0].W.B1.CLK_B
+ SLICE[2].RAM8x32.WORD[0].W.B1.we_wire VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[0].W.B1.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[2].RAM8x32.WORD[0].W.B1.CGAND SLICE[2].RAM8x32.WORD[0].W.B0.SEL
+ SLICE[2].RAM8x32.WORD[0].W.B1.WE VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[0].W.B1.we_wire sky130_fd_sc_hd__and2_1
XSLICE[2].RAM8x32.WORD[0].W.B1.CLKINV SLICE[2].RAM8x32.WORD[0].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[0].W.B1.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[0].W.B1.SELINV SLICE[2].RAM8x32.WORD[0].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[0].W.B1.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[0].W.B2.BIT[0].LATCH SLICE[0].RAM8x32.Di[16]
+ SLICE[2].RAM8x32.WORD[0].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[0].W.B2.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[0].W.B2.BIT[0].OBUF
+ SLICE[2].RAM8x32.WORD[0].W.B2.q_wire[0] SLICE[2].RAM8x32.WORD[0].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[16] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[0].W.B2.BIT[1].LATCH SLICE[0].RAM8x32.Di[17]
+ SLICE[2].RAM8x32.WORD[0].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[0].W.B2.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[0].W.B2.BIT[1].OBUF
+ SLICE[2].RAM8x32.WORD[0].W.B2.q_wire[1] SLICE[2].RAM8x32.WORD[0].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[17] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[0].W.B2.BIT[2].LATCH SLICE[0].RAM8x32.Di[18]
+ SLICE[2].RAM8x32.WORD[0].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[0].W.B2.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[0].W.B2.BIT[2].OBUF
+ SLICE[2].RAM8x32.WORD[0].W.B2.q_wire[2] SLICE[2].RAM8x32.WORD[0].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[18] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[0].W.B2.BIT[3].LATCH SLICE[0].RAM8x32.Di[19]
+ SLICE[2].RAM8x32.WORD[0].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[0].W.B2.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[0].W.B2.BIT[3].OBUF
+ SLICE[2].RAM8x32.WORD[0].W.B2.q_wire[3] SLICE[2].RAM8x32.WORD[0].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[19] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[0].W.B2.BIT[4].LATCH SLICE[0].RAM8x32.Di[20]
+ SLICE[2].RAM8x32.WORD[0].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[0].W.B2.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[0].W.B2.BIT[4].OBUF
+ SLICE[2].RAM8x32.WORD[0].W.B2.q_wire[4] SLICE[2].RAM8x32.WORD[0].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[20] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[0].W.B2.BIT[5].LATCH SLICE[0].RAM8x32.Di[21]
+ SLICE[2].RAM8x32.WORD[0].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[0].W.B2.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[0].W.B2.BIT[5].OBUF
+ SLICE[2].RAM8x32.WORD[0].W.B2.q_wire[5] SLICE[2].RAM8x32.WORD[0].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[21] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[0].W.B2.BIT[6].LATCH SLICE[0].RAM8x32.Di[22]
+ SLICE[2].RAM8x32.WORD[0].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[0].W.B2.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[0].W.B2.BIT[6].OBUF
+ SLICE[2].RAM8x32.WORD[0].W.B2.q_wire[6] SLICE[2].RAM8x32.WORD[0].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[22] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[0].W.B2.BIT[7].LATCH SLICE[0].RAM8x32.Di[23]
+ SLICE[2].RAM8x32.WORD[0].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[0].W.B2.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[0].W.B2.BIT[7].OBUF
+ SLICE[2].RAM8x32.WORD[0].W.B2.q_wire[7] SLICE[2].RAM8x32.WORD[0].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[23] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[0].W.B2.CG SLICE[2].RAM8x32.WORD[0].W.B2.CLK_B
+ SLICE[2].RAM8x32.WORD[0].W.B2.we_wire VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[0].W.B2.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[2].RAM8x32.WORD[0].W.B2.CGAND SLICE[2].RAM8x32.WORD[0].W.B0.SEL
+ SLICE[2].RAM8x32.WORD[0].W.B2.WE VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[0].W.B2.we_wire sky130_fd_sc_hd__and2_1
XSLICE[2].RAM8x32.WORD[0].W.B2.CLKINV SLICE[2].RAM8x32.WORD[0].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[0].W.B2.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[0].W.B2.SELINV SLICE[2].RAM8x32.WORD[0].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[0].W.B2.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[0].W.B3.BIT[0].LATCH SLICE[0].RAM8x32.Di[24]
+ SLICE[2].RAM8x32.WORD[0].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[0].W.B3.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[0].W.B3.BIT[0].OBUF
+ SLICE[2].RAM8x32.WORD[0].W.B3.q_wire[0] SLICE[2].RAM8x32.WORD[0].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[24] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[0].W.B3.BIT[1].LATCH SLICE[0].RAM8x32.Di[25]
+ SLICE[2].RAM8x32.WORD[0].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[0].W.B3.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[0].W.B3.BIT[1].OBUF
+ SLICE[2].RAM8x32.WORD[0].W.B3.q_wire[1] SLICE[2].RAM8x32.WORD[0].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[25] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[0].W.B3.BIT[2].LATCH SLICE[0].RAM8x32.Di[26]
+ SLICE[2].RAM8x32.WORD[0].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[0].W.B3.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[0].W.B3.BIT[2].OBUF
+ SLICE[2].RAM8x32.WORD[0].W.B3.q_wire[2] SLICE[2].RAM8x32.WORD[0].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[26] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[0].W.B3.BIT[3].LATCH SLICE[0].RAM8x32.Di[27]
+ SLICE[2].RAM8x32.WORD[0].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[0].W.B3.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[0].W.B3.BIT[3].OBUF
+ SLICE[2].RAM8x32.WORD[0].W.B3.q_wire[3] SLICE[2].RAM8x32.WORD[0].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[27] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[0].W.B3.BIT[4].LATCH SLICE[0].RAM8x32.Di[28]
+ SLICE[2].RAM8x32.WORD[0].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[0].W.B3.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[0].W.B3.BIT[4].OBUF
+ SLICE[2].RAM8x32.WORD[0].W.B3.q_wire[4] SLICE[2].RAM8x32.WORD[0].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[28] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[0].W.B3.BIT[5].LATCH SLICE[0].RAM8x32.Di[29]
+ SLICE[2].RAM8x32.WORD[0].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[0].W.B3.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[0].W.B3.BIT[5].OBUF
+ SLICE[2].RAM8x32.WORD[0].W.B3.q_wire[5] SLICE[2].RAM8x32.WORD[0].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[29] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[0].W.B3.BIT[6].LATCH SLICE[0].RAM8x32.Di[30]
+ SLICE[2].RAM8x32.WORD[0].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[0].W.B3.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[0].W.B3.BIT[6].OBUF
+ SLICE[2].RAM8x32.WORD[0].W.B3.q_wire[6] SLICE[2].RAM8x32.WORD[0].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[30] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[0].W.B3.BIT[7].LATCH SLICE[0].RAM8x32.Di[31]
+ SLICE[2].RAM8x32.WORD[0].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[0].W.B3.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[0].W.B3.BIT[7].OBUF
+ SLICE[2].RAM8x32.WORD[0].W.B3.q_wire[7] SLICE[2].RAM8x32.WORD[0].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[31] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[0].W.B3.CG SLICE[2].RAM8x32.WORD[0].W.B3.CLK_B
+ SLICE[2].RAM8x32.WORD[0].W.B3.we_wire VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[0].W.B3.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[2].RAM8x32.WORD[0].W.B3.CGAND SLICE[2].RAM8x32.WORD[0].W.B0.SEL
+ SLICE[2].RAM8x32.WORD[0].W.B3.WE VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[0].W.B3.we_wire sky130_fd_sc_hd__and2_1
XSLICE[2].RAM8x32.WORD[0].W.B3.CLKINV SLICE[2].RAM8x32.WORD[0].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[0].W.B3.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[0].W.B3.SELINV SLICE[2].RAM8x32.WORD[0].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[0].W.B3.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[0].W.CLKBUF SLICE[2].RAM8x32.CLK_buf VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[0].W.B0.CLK sky130_fd_sc_hd__clkbuf_1
XSLICE[2].RAM8x32.WORD[0].W.SELBUF SLICE[2].RAM8x32.WORD[0].W.SEL VGND VGND
+ VPWR VPWR SLICE[2].RAM8x32.WORD[0].W.B0.SEL sky130_fd_sc_hd__clkbuf_2
XSLICE[2].RAM8x32.WORD[1].W.B0.BIT[0].LATCH SLICE[0].RAM8x32.Di[0]
+ SLICE[2].RAM8x32.WORD[1].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[1].W.B0.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[1].W.B0.BIT[0].OBUF
+ SLICE[2].RAM8x32.WORD[1].W.B0.q_wire[0] SLICE[2].RAM8x32.WORD[1].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[0] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[1].W.B0.BIT[1].LATCH SLICE[0].RAM8x32.Di[1]
+ SLICE[2].RAM8x32.WORD[1].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[1].W.B0.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[1].W.B0.BIT[1].OBUF
+ SLICE[2].RAM8x32.WORD[1].W.B0.q_wire[1] SLICE[2].RAM8x32.WORD[1].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[1] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[1].W.B0.BIT[2].LATCH SLICE[0].RAM8x32.Di[2]
+ SLICE[2].RAM8x32.WORD[1].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[1].W.B0.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[1].W.B0.BIT[2].OBUF
+ SLICE[2].RAM8x32.WORD[1].W.B0.q_wire[2] SLICE[2].RAM8x32.WORD[1].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[2] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[1].W.B0.BIT[3].LATCH SLICE[0].RAM8x32.Di[3]
+ SLICE[2].RAM8x32.WORD[1].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[1].W.B0.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[1].W.B0.BIT[3].OBUF
+ SLICE[2].RAM8x32.WORD[1].W.B0.q_wire[3] SLICE[2].RAM8x32.WORD[1].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[3] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[1].W.B0.BIT[4].LATCH SLICE[0].RAM8x32.Di[4]
+ SLICE[2].RAM8x32.WORD[1].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[1].W.B0.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[1].W.B0.BIT[4].OBUF
+ SLICE[2].RAM8x32.WORD[1].W.B0.q_wire[4] SLICE[2].RAM8x32.WORD[1].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[4] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[1].W.B0.BIT[5].LATCH SLICE[0].RAM8x32.Di[5]
+ SLICE[2].RAM8x32.WORD[1].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[1].W.B0.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[1].W.B0.BIT[5].OBUF
+ SLICE[2].RAM8x32.WORD[1].W.B0.q_wire[5] SLICE[2].RAM8x32.WORD[1].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[5] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[1].W.B0.BIT[6].LATCH SLICE[0].RAM8x32.Di[6]
+ SLICE[2].RAM8x32.WORD[1].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[1].W.B0.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[1].W.B0.BIT[6].OBUF
+ SLICE[2].RAM8x32.WORD[1].W.B0.q_wire[6] SLICE[2].RAM8x32.WORD[1].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[6] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[1].W.B0.BIT[7].LATCH SLICE[0].RAM8x32.Di[7]
+ SLICE[2].RAM8x32.WORD[1].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[1].W.B0.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[1].W.B0.BIT[7].OBUF
+ SLICE[2].RAM8x32.WORD[1].W.B0.q_wire[7] SLICE[2].RAM8x32.WORD[1].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[7] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[1].W.B0.CG SLICE[2].RAM8x32.WORD[1].W.B0.CLK_B
+ SLICE[2].RAM8x32.WORD[1].W.B0.we_wire VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[1].W.B0.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[2].RAM8x32.WORD[1].W.B0.CGAND SLICE[2].RAM8x32.WORD[1].W.B0.SEL
+ SLICE[2].RAM8x32.WORD[0].W.B0.WE VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[1].W.B0.we_wire sky130_fd_sc_hd__and2_1
XSLICE[2].RAM8x32.WORD[1].W.B0.CLKINV SLICE[2].RAM8x32.WORD[1].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[1].W.B0.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[1].W.B0.SELINV SLICE[2].RAM8x32.WORD[1].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[1].W.B0.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[1].W.B1.BIT[0].LATCH SLICE[0].RAM8x32.Di[8]
+ SLICE[2].RAM8x32.WORD[1].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[1].W.B1.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[1].W.B1.BIT[0].OBUF
+ SLICE[2].RAM8x32.WORD[1].W.B1.q_wire[0] SLICE[2].RAM8x32.WORD[1].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[8] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[1].W.B1.BIT[1].LATCH SLICE[0].RAM8x32.Di[9]
+ SLICE[2].RAM8x32.WORD[1].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[1].W.B1.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[1].W.B1.BIT[1].OBUF
+ SLICE[2].RAM8x32.WORD[1].W.B1.q_wire[1] SLICE[2].RAM8x32.WORD[1].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[9] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[1].W.B1.BIT[2].LATCH SLICE[0].RAM8x32.Di[10]
+ SLICE[2].RAM8x32.WORD[1].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[1].W.B1.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[1].W.B1.BIT[2].OBUF
+ SLICE[2].RAM8x32.WORD[1].W.B1.q_wire[2] SLICE[2].RAM8x32.WORD[1].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[10] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[1].W.B1.BIT[3].LATCH SLICE[0].RAM8x32.Di[11]
+ SLICE[2].RAM8x32.WORD[1].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[1].W.B1.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[1].W.B1.BIT[3].OBUF
+ SLICE[2].RAM8x32.WORD[1].W.B1.q_wire[3] SLICE[2].RAM8x32.WORD[1].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[11] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[1].W.B1.BIT[4].LATCH SLICE[0].RAM8x32.Di[12]
+ SLICE[2].RAM8x32.WORD[1].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[1].W.B1.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[1].W.B1.BIT[4].OBUF
+ SLICE[2].RAM8x32.WORD[1].W.B1.q_wire[4] SLICE[2].RAM8x32.WORD[1].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[12] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[1].W.B1.BIT[5].LATCH SLICE[0].RAM8x32.Di[13]
+ SLICE[2].RAM8x32.WORD[1].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[1].W.B1.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[1].W.B1.BIT[5].OBUF
+ SLICE[2].RAM8x32.WORD[1].W.B1.q_wire[5] SLICE[2].RAM8x32.WORD[1].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[13] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[1].W.B1.BIT[6].LATCH SLICE[0].RAM8x32.Di[14]
+ SLICE[2].RAM8x32.WORD[1].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[1].W.B1.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[1].W.B1.BIT[6].OBUF
+ SLICE[2].RAM8x32.WORD[1].W.B1.q_wire[6] SLICE[2].RAM8x32.WORD[1].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[14] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[1].W.B1.BIT[7].LATCH SLICE[0].RAM8x32.Di[15]
+ SLICE[2].RAM8x32.WORD[1].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[1].W.B1.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[1].W.B1.BIT[7].OBUF
+ SLICE[2].RAM8x32.WORD[1].W.B1.q_wire[7] SLICE[2].RAM8x32.WORD[1].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[15] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[1].W.B1.CG SLICE[2].RAM8x32.WORD[1].W.B1.CLK_B
+ SLICE[2].RAM8x32.WORD[1].W.B1.we_wire VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[1].W.B1.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[2].RAM8x32.WORD[1].W.B1.CGAND SLICE[2].RAM8x32.WORD[1].W.B0.SEL
+ SLICE[2].RAM8x32.WORD[0].W.B1.WE VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[1].W.B1.we_wire sky130_fd_sc_hd__and2_1
XSLICE[2].RAM8x32.WORD[1].W.B1.CLKINV SLICE[2].RAM8x32.WORD[1].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[1].W.B1.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[1].W.B1.SELINV SLICE[2].RAM8x32.WORD[1].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[1].W.B1.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[1].W.B2.BIT[0].LATCH SLICE[0].RAM8x32.Di[16]
+ SLICE[2].RAM8x32.WORD[1].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[1].W.B2.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[1].W.B2.BIT[0].OBUF
+ SLICE[2].RAM8x32.WORD[1].W.B2.q_wire[0] SLICE[2].RAM8x32.WORD[1].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[16] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[1].W.B2.BIT[1].LATCH SLICE[0].RAM8x32.Di[17]
+ SLICE[2].RAM8x32.WORD[1].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[1].W.B2.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[1].W.B2.BIT[1].OBUF
+ SLICE[2].RAM8x32.WORD[1].W.B2.q_wire[1] SLICE[2].RAM8x32.WORD[1].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[17] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[1].W.B2.BIT[2].LATCH SLICE[0].RAM8x32.Di[18]
+ SLICE[2].RAM8x32.WORD[1].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[1].W.B2.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[1].W.B2.BIT[2].OBUF
+ SLICE[2].RAM8x32.WORD[1].W.B2.q_wire[2] SLICE[2].RAM8x32.WORD[1].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[18] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[1].W.B2.BIT[3].LATCH SLICE[0].RAM8x32.Di[19]
+ SLICE[2].RAM8x32.WORD[1].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[1].W.B2.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[1].W.B2.BIT[3].OBUF
+ SLICE[2].RAM8x32.WORD[1].W.B2.q_wire[3] SLICE[2].RAM8x32.WORD[1].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[19] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[1].W.B2.BIT[4].LATCH SLICE[0].RAM8x32.Di[20]
+ SLICE[2].RAM8x32.WORD[1].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[1].W.B2.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[1].W.B2.BIT[4].OBUF
+ SLICE[2].RAM8x32.WORD[1].W.B2.q_wire[4] SLICE[2].RAM8x32.WORD[1].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[20] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[1].W.B2.BIT[5].LATCH SLICE[0].RAM8x32.Di[21]
+ SLICE[2].RAM8x32.WORD[1].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[1].W.B2.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[1].W.B2.BIT[5].OBUF
+ SLICE[2].RAM8x32.WORD[1].W.B2.q_wire[5] SLICE[2].RAM8x32.WORD[1].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[21] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[1].W.B2.BIT[6].LATCH SLICE[0].RAM8x32.Di[22]
+ SLICE[2].RAM8x32.WORD[1].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[1].W.B2.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[1].W.B2.BIT[6].OBUF
+ SLICE[2].RAM8x32.WORD[1].W.B2.q_wire[6] SLICE[2].RAM8x32.WORD[1].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[22] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[1].W.B2.BIT[7].LATCH SLICE[0].RAM8x32.Di[23]
+ SLICE[2].RAM8x32.WORD[1].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[1].W.B2.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[1].W.B2.BIT[7].OBUF
+ SLICE[2].RAM8x32.WORD[1].W.B2.q_wire[7] SLICE[2].RAM8x32.WORD[1].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[23] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[1].W.B2.CG SLICE[2].RAM8x32.WORD[1].W.B2.CLK_B
+ SLICE[2].RAM8x32.WORD[1].W.B2.we_wire VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[1].W.B2.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[2].RAM8x32.WORD[1].W.B2.CGAND SLICE[2].RAM8x32.WORD[1].W.B0.SEL
+ SLICE[2].RAM8x32.WORD[0].W.B2.WE VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[1].W.B2.we_wire sky130_fd_sc_hd__and2_1
XSLICE[2].RAM8x32.WORD[1].W.B2.CLKINV SLICE[2].RAM8x32.WORD[1].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[1].W.B2.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[1].W.B2.SELINV SLICE[2].RAM8x32.WORD[1].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[1].W.B2.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[1].W.B3.BIT[0].LATCH SLICE[0].RAM8x32.Di[24]
+ SLICE[2].RAM8x32.WORD[1].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[1].W.B3.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[1].W.B3.BIT[0].OBUF
+ SLICE[2].RAM8x32.WORD[1].W.B3.q_wire[0] SLICE[2].RAM8x32.WORD[1].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[24] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[1].W.B3.BIT[1].LATCH SLICE[0].RAM8x32.Di[25]
+ SLICE[2].RAM8x32.WORD[1].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[1].W.B3.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[1].W.B3.BIT[1].OBUF
+ SLICE[2].RAM8x32.WORD[1].W.B3.q_wire[1] SLICE[2].RAM8x32.WORD[1].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[25] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[1].W.B3.BIT[2].LATCH SLICE[0].RAM8x32.Di[26]
+ SLICE[2].RAM8x32.WORD[1].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[1].W.B3.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[1].W.B3.BIT[2].OBUF
+ SLICE[2].RAM8x32.WORD[1].W.B3.q_wire[2] SLICE[2].RAM8x32.WORD[1].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[26] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[1].W.B3.BIT[3].LATCH SLICE[0].RAM8x32.Di[27]
+ SLICE[2].RAM8x32.WORD[1].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[1].W.B3.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[1].W.B3.BIT[3].OBUF
+ SLICE[2].RAM8x32.WORD[1].W.B3.q_wire[3] SLICE[2].RAM8x32.WORD[1].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[27] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[1].W.B3.BIT[4].LATCH SLICE[0].RAM8x32.Di[28]
+ SLICE[2].RAM8x32.WORD[1].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[1].W.B3.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[1].W.B3.BIT[4].OBUF
+ SLICE[2].RAM8x32.WORD[1].W.B3.q_wire[4] SLICE[2].RAM8x32.WORD[1].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[28] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[1].W.B3.BIT[5].LATCH SLICE[0].RAM8x32.Di[29]
+ SLICE[2].RAM8x32.WORD[1].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[1].W.B3.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[1].W.B3.BIT[5].OBUF
+ SLICE[2].RAM8x32.WORD[1].W.B3.q_wire[5] SLICE[2].RAM8x32.WORD[1].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[29] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[1].W.B3.BIT[6].LATCH SLICE[0].RAM8x32.Di[30]
+ SLICE[2].RAM8x32.WORD[1].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[1].W.B3.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[1].W.B3.BIT[6].OBUF
+ SLICE[2].RAM8x32.WORD[1].W.B3.q_wire[6] SLICE[2].RAM8x32.WORD[1].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[30] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[1].W.B3.BIT[7].LATCH SLICE[0].RAM8x32.Di[31]
+ SLICE[2].RAM8x32.WORD[1].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[1].W.B3.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[1].W.B3.BIT[7].OBUF
+ SLICE[2].RAM8x32.WORD[1].W.B3.q_wire[7] SLICE[2].RAM8x32.WORD[1].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[31] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[1].W.B3.CG SLICE[2].RAM8x32.WORD[1].W.B3.CLK_B
+ SLICE[2].RAM8x32.WORD[1].W.B3.we_wire VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[1].W.B3.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[2].RAM8x32.WORD[1].W.B3.CGAND SLICE[2].RAM8x32.WORD[1].W.B0.SEL
+ SLICE[2].RAM8x32.WORD[0].W.B3.WE VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[1].W.B3.we_wire sky130_fd_sc_hd__and2_1
XSLICE[2].RAM8x32.WORD[1].W.B3.CLKINV SLICE[2].RAM8x32.WORD[1].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[1].W.B3.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[1].W.B3.SELINV SLICE[2].RAM8x32.WORD[1].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[1].W.B3.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[1].W.CLKBUF SLICE[2].RAM8x32.CLK_buf VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[1].W.B0.CLK sky130_fd_sc_hd__clkbuf_1
XSLICE[2].RAM8x32.WORD[1].W.SELBUF SLICE[2].RAM8x32.WORD[1].W.SEL VGND VGND
+ VPWR VPWR SLICE[2].RAM8x32.WORD[1].W.B0.SEL sky130_fd_sc_hd__clkbuf_2
XSLICE[2].RAM8x32.WORD[2].W.B0.BIT[0].LATCH SLICE[0].RAM8x32.Di[0]
+ SLICE[2].RAM8x32.WORD[2].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[2].W.B0.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[2].W.B0.BIT[0].OBUF
+ SLICE[2].RAM8x32.WORD[2].W.B0.q_wire[0] SLICE[2].RAM8x32.WORD[2].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[0] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[2].W.B0.BIT[1].LATCH SLICE[0].RAM8x32.Di[1]
+ SLICE[2].RAM8x32.WORD[2].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[2].W.B0.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[2].W.B0.BIT[1].OBUF
+ SLICE[2].RAM8x32.WORD[2].W.B0.q_wire[1] SLICE[2].RAM8x32.WORD[2].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[1] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[2].W.B0.BIT[2].LATCH SLICE[0].RAM8x32.Di[2]
+ SLICE[2].RAM8x32.WORD[2].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[2].W.B0.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[2].W.B0.BIT[2].OBUF
+ SLICE[2].RAM8x32.WORD[2].W.B0.q_wire[2] SLICE[2].RAM8x32.WORD[2].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[2] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[2].W.B0.BIT[3].LATCH SLICE[0].RAM8x32.Di[3]
+ SLICE[2].RAM8x32.WORD[2].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[2].W.B0.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[2].W.B0.BIT[3].OBUF
+ SLICE[2].RAM8x32.WORD[2].W.B0.q_wire[3] SLICE[2].RAM8x32.WORD[2].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[3] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[2].W.B0.BIT[4].LATCH SLICE[0].RAM8x32.Di[4]
+ SLICE[2].RAM8x32.WORD[2].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[2].W.B0.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[2].W.B0.BIT[4].OBUF
+ SLICE[2].RAM8x32.WORD[2].W.B0.q_wire[4] SLICE[2].RAM8x32.WORD[2].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[4] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[2].W.B0.BIT[5].LATCH SLICE[0].RAM8x32.Di[5]
+ SLICE[2].RAM8x32.WORD[2].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[2].W.B0.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[2].W.B0.BIT[5].OBUF
+ SLICE[2].RAM8x32.WORD[2].W.B0.q_wire[5] SLICE[2].RAM8x32.WORD[2].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[5] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[2].W.B0.BIT[6].LATCH SLICE[0].RAM8x32.Di[6]
+ SLICE[2].RAM8x32.WORD[2].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[2].W.B0.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[2].W.B0.BIT[6].OBUF
+ SLICE[2].RAM8x32.WORD[2].W.B0.q_wire[6] SLICE[2].RAM8x32.WORD[2].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[6] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[2].W.B0.BIT[7].LATCH SLICE[0].RAM8x32.Di[7]
+ SLICE[2].RAM8x32.WORD[2].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[2].W.B0.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[2].W.B0.BIT[7].OBUF
+ SLICE[2].RAM8x32.WORD[2].W.B0.q_wire[7] SLICE[2].RAM8x32.WORD[2].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[7] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[2].W.B0.CG SLICE[2].RAM8x32.WORD[2].W.B0.CLK_B
+ SLICE[2].RAM8x32.WORD[2].W.B0.we_wire VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[2].W.B0.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[2].RAM8x32.WORD[2].W.B0.CGAND SLICE[2].RAM8x32.WORD[2].W.B0.SEL
+ SLICE[2].RAM8x32.WORD[0].W.B0.WE VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[2].W.B0.we_wire sky130_fd_sc_hd__and2_1
XSLICE[2].RAM8x32.WORD[2].W.B0.CLKINV SLICE[2].RAM8x32.WORD[2].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[2].W.B0.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[2].W.B0.SELINV SLICE[2].RAM8x32.WORD[2].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[2].W.B0.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[2].W.B1.BIT[0].LATCH SLICE[0].RAM8x32.Di[8]
+ SLICE[2].RAM8x32.WORD[2].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[2].W.B1.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[2].W.B1.BIT[0].OBUF
+ SLICE[2].RAM8x32.WORD[2].W.B1.q_wire[0] SLICE[2].RAM8x32.WORD[2].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[8] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[2].W.B1.BIT[1].LATCH SLICE[0].RAM8x32.Di[9]
+ SLICE[2].RAM8x32.WORD[2].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[2].W.B1.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[2].W.B1.BIT[1].OBUF
+ SLICE[2].RAM8x32.WORD[2].W.B1.q_wire[1] SLICE[2].RAM8x32.WORD[2].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[9] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[2].W.B1.BIT[2].LATCH SLICE[0].RAM8x32.Di[10]
+ SLICE[2].RAM8x32.WORD[2].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[2].W.B1.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[2].W.B1.BIT[2].OBUF
+ SLICE[2].RAM8x32.WORD[2].W.B1.q_wire[2] SLICE[2].RAM8x32.WORD[2].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[10] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[2].W.B1.BIT[3].LATCH SLICE[0].RAM8x32.Di[11]
+ SLICE[2].RAM8x32.WORD[2].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[2].W.B1.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[2].W.B1.BIT[3].OBUF
+ SLICE[2].RAM8x32.WORD[2].W.B1.q_wire[3] SLICE[2].RAM8x32.WORD[2].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[11] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[2].W.B1.BIT[4].LATCH SLICE[0].RAM8x32.Di[12]
+ SLICE[2].RAM8x32.WORD[2].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[2].W.B1.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[2].W.B1.BIT[4].OBUF
+ SLICE[2].RAM8x32.WORD[2].W.B1.q_wire[4] SLICE[2].RAM8x32.WORD[2].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[12] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[2].W.B1.BIT[5].LATCH SLICE[0].RAM8x32.Di[13]
+ SLICE[2].RAM8x32.WORD[2].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[2].W.B1.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[2].W.B1.BIT[5].OBUF
+ SLICE[2].RAM8x32.WORD[2].W.B1.q_wire[5] SLICE[2].RAM8x32.WORD[2].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[13] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[2].W.B1.BIT[6].LATCH SLICE[0].RAM8x32.Di[14]
+ SLICE[2].RAM8x32.WORD[2].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[2].W.B1.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[2].W.B1.BIT[6].OBUF
+ SLICE[2].RAM8x32.WORD[2].W.B1.q_wire[6] SLICE[2].RAM8x32.WORD[2].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[14] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[2].W.B1.BIT[7].LATCH SLICE[0].RAM8x32.Di[15]
+ SLICE[2].RAM8x32.WORD[2].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[2].W.B1.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[2].W.B1.BIT[7].OBUF
+ SLICE[2].RAM8x32.WORD[2].W.B1.q_wire[7] SLICE[2].RAM8x32.WORD[2].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[15] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[2].W.B1.CG SLICE[2].RAM8x32.WORD[2].W.B1.CLK_B
+ SLICE[2].RAM8x32.WORD[2].W.B1.we_wire VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[2].W.B1.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[2].RAM8x32.WORD[2].W.B1.CGAND SLICE[2].RAM8x32.WORD[2].W.B0.SEL
+ SLICE[2].RAM8x32.WORD[0].W.B1.WE VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[2].W.B1.we_wire sky130_fd_sc_hd__and2_1
XSLICE[2].RAM8x32.WORD[2].W.B1.CLKINV SLICE[2].RAM8x32.WORD[2].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[2].W.B1.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[2].W.B1.SELINV SLICE[2].RAM8x32.WORD[2].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[2].W.B1.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[2].W.B2.BIT[0].LATCH SLICE[0].RAM8x32.Di[16]
+ SLICE[2].RAM8x32.WORD[2].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[2].W.B2.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[2].W.B2.BIT[0].OBUF
+ SLICE[2].RAM8x32.WORD[2].W.B2.q_wire[0] SLICE[2].RAM8x32.WORD[2].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[16] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[2].W.B2.BIT[1].LATCH SLICE[0].RAM8x32.Di[17]
+ SLICE[2].RAM8x32.WORD[2].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[2].W.B2.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[2].W.B2.BIT[1].OBUF
+ SLICE[2].RAM8x32.WORD[2].W.B2.q_wire[1] SLICE[2].RAM8x32.WORD[2].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[17] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[2].W.B2.BIT[2].LATCH SLICE[0].RAM8x32.Di[18]
+ SLICE[2].RAM8x32.WORD[2].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[2].W.B2.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[2].W.B2.BIT[2].OBUF
+ SLICE[2].RAM8x32.WORD[2].W.B2.q_wire[2] SLICE[2].RAM8x32.WORD[2].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[18] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[2].W.B2.BIT[3].LATCH SLICE[0].RAM8x32.Di[19]
+ SLICE[2].RAM8x32.WORD[2].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[2].W.B2.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[2].W.B2.BIT[3].OBUF
+ SLICE[2].RAM8x32.WORD[2].W.B2.q_wire[3] SLICE[2].RAM8x32.WORD[2].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[19] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[2].W.B2.BIT[4].LATCH SLICE[0].RAM8x32.Di[20]
+ SLICE[2].RAM8x32.WORD[2].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[2].W.B2.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[2].W.B2.BIT[4].OBUF
+ SLICE[2].RAM8x32.WORD[2].W.B2.q_wire[4] SLICE[2].RAM8x32.WORD[2].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[20] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[2].W.B2.BIT[5].LATCH SLICE[0].RAM8x32.Di[21]
+ SLICE[2].RAM8x32.WORD[2].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[2].W.B2.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[2].W.B2.BIT[5].OBUF
+ SLICE[2].RAM8x32.WORD[2].W.B2.q_wire[5] SLICE[2].RAM8x32.WORD[2].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[21] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[2].W.B2.BIT[6].LATCH SLICE[0].RAM8x32.Di[22]
+ SLICE[2].RAM8x32.WORD[2].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[2].W.B2.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[2].W.B2.BIT[6].OBUF
+ SLICE[2].RAM8x32.WORD[2].W.B2.q_wire[6] SLICE[2].RAM8x32.WORD[2].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[22] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[2].W.B2.BIT[7].LATCH SLICE[0].RAM8x32.Di[23]
+ SLICE[2].RAM8x32.WORD[2].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[2].W.B2.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[2].W.B2.BIT[7].OBUF
+ SLICE[2].RAM8x32.WORD[2].W.B2.q_wire[7] SLICE[2].RAM8x32.WORD[2].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[23] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[2].W.B2.CG SLICE[2].RAM8x32.WORD[2].W.B2.CLK_B
+ SLICE[2].RAM8x32.WORD[2].W.B2.we_wire VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[2].W.B2.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[2].RAM8x32.WORD[2].W.B2.CGAND SLICE[2].RAM8x32.WORD[2].W.B0.SEL
+ SLICE[2].RAM8x32.WORD[0].W.B2.WE VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[2].W.B2.we_wire sky130_fd_sc_hd__and2_1
XSLICE[2].RAM8x32.WORD[2].W.B2.CLKINV SLICE[2].RAM8x32.WORD[2].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[2].W.B2.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[2].W.B2.SELINV SLICE[2].RAM8x32.WORD[2].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[2].W.B2.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[2].W.B3.BIT[0].LATCH SLICE[0].RAM8x32.Di[24]
+ SLICE[2].RAM8x32.WORD[2].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[2].W.B3.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[2].W.B3.BIT[0].OBUF
+ SLICE[2].RAM8x32.WORD[2].W.B3.q_wire[0] SLICE[2].RAM8x32.WORD[2].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[24] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[2].W.B3.BIT[1].LATCH SLICE[0].RAM8x32.Di[25]
+ SLICE[2].RAM8x32.WORD[2].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[2].W.B3.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[2].W.B3.BIT[1].OBUF
+ SLICE[2].RAM8x32.WORD[2].W.B3.q_wire[1] SLICE[2].RAM8x32.WORD[2].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[25] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[2].W.B3.BIT[2].LATCH SLICE[0].RAM8x32.Di[26]
+ SLICE[2].RAM8x32.WORD[2].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[2].W.B3.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[2].W.B3.BIT[2].OBUF
+ SLICE[2].RAM8x32.WORD[2].W.B3.q_wire[2] SLICE[2].RAM8x32.WORD[2].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[26] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[2].W.B3.BIT[3].LATCH SLICE[0].RAM8x32.Di[27]
+ SLICE[2].RAM8x32.WORD[2].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[2].W.B3.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[2].W.B3.BIT[3].OBUF
+ SLICE[2].RAM8x32.WORD[2].W.B3.q_wire[3] SLICE[2].RAM8x32.WORD[2].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[27] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[2].W.B3.BIT[4].LATCH SLICE[0].RAM8x32.Di[28]
+ SLICE[2].RAM8x32.WORD[2].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[2].W.B3.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[2].W.B3.BIT[4].OBUF
+ SLICE[2].RAM8x32.WORD[2].W.B3.q_wire[4] SLICE[2].RAM8x32.WORD[2].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[28] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[2].W.B3.BIT[5].LATCH SLICE[0].RAM8x32.Di[29]
+ SLICE[2].RAM8x32.WORD[2].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[2].W.B3.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[2].W.B3.BIT[5].OBUF
+ SLICE[2].RAM8x32.WORD[2].W.B3.q_wire[5] SLICE[2].RAM8x32.WORD[2].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[29] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[2].W.B3.BIT[6].LATCH SLICE[0].RAM8x32.Di[30]
+ SLICE[2].RAM8x32.WORD[2].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[2].W.B3.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[2].W.B3.BIT[6].OBUF
+ SLICE[2].RAM8x32.WORD[2].W.B3.q_wire[6] SLICE[2].RAM8x32.WORD[2].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[30] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[2].W.B3.BIT[7].LATCH SLICE[0].RAM8x32.Di[31]
+ SLICE[2].RAM8x32.WORD[2].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[2].W.B3.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[2].W.B3.BIT[7].OBUF
+ SLICE[2].RAM8x32.WORD[2].W.B3.q_wire[7] SLICE[2].RAM8x32.WORD[2].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[31] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[2].W.B3.CG SLICE[2].RAM8x32.WORD[2].W.B3.CLK_B
+ SLICE[2].RAM8x32.WORD[2].W.B3.we_wire VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[2].W.B3.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[2].RAM8x32.WORD[2].W.B3.CGAND SLICE[2].RAM8x32.WORD[2].W.B0.SEL
+ SLICE[2].RAM8x32.WORD[0].W.B3.WE VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[2].W.B3.we_wire sky130_fd_sc_hd__and2_1
XSLICE[2].RAM8x32.WORD[2].W.B3.CLKINV SLICE[2].RAM8x32.WORD[2].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[2].W.B3.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[2].W.B3.SELINV SLICE[2].RAM8x32.WORD[2].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[2].W.B3.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[2].W.CLKBUF SLICE[2].RAM8x32.CLK_buf VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[2].W.B0.CLK sky130_fd_sc_hd__clkbuf_1
XSLICE[2].RAM8x32.WORD[2].W.SELBUF SLICE[2].RAM8x32.WORD[2].W.SEL VGND VGND
+ VPWR VPWR SLICE[2].RAM8x32.WORD[2].W.B0.SEL sky130_fd_sc_hd__clkbuf_2
XSLICE[2].RAM8x32.WORD[3].W.B0.BIT[0].LATCH SLICE[0].RAM8x32.Di[0]
+ SLICE[2].RAM8x32.WORD[3].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[3].W.B0.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[3].W.B0.BIT[0].OBUF
+ SLICE[2].RAM8x32.WORD[3].W.B0.q_wire[0] SLICE[2].RAM8x32.WORD[3].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[0] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[3].W.B0.BIT[1].LATCH SLICE[0].RAM8x32.Di[1]
+ SLICE[2].RAM8x32.WORD[3].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[3].W.B0.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[3].W.B0.BIT[1].OBUF
+ SLICE[2].RAM8x32.WORD[3].W.B0.q_wire[1] SLICE[2].RAM8x32.WORD[3].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[1] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[3].W.B0.BIT[2].LATCH SLICE[0].RAM8x32.Di[2]
+ SLICE[2].RAM8x32.WORD[3].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[3].W.B0.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[3].W.B0.BIT[2].OBUF
+ SLICE[2].RAM8x32.WORD[3].W.B0.q_wire[2] SLICE[2].RAM8x32.WORD[3].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[2] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[3].W.B0.BIT[3].LATCH SLICE[0].RAM8x32.Di[3]
+ SLICE[2].RAM8x32.WORD[3].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[3].W.B0.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[3].W.B0.BIT[3].OBUF
+ SLICE[2].RAM8x32.WORD[3].W.B0.q_wire[3] SLICE[2].RAM8x32.WORD[3].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[3] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[3].W.B0.BIT[4].LATCH SLICE[0].RAM8x32.Di[4]
+ SLICE[2].RAM8x32.WORD[3].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[3].W.B0.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[3].W.B0.BIT[4].OBUF
+ SLICE[2].RAM8x32.WORD[3].W.B0.q_wire[4] SLICE[2].RAM8x32.WORD[3].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[4] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[3].W.B0.BIT[5].LATCH SLICE[0].RAM8x32.Di[5]
+ SLICE[2].RAM8x32.WORD[3].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[3].W.B0.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[3].W.B0.BIT[5].OBUF
+ SLICE[2].RAM8x32.WORD[3].W.B0.q_wire[5] SLICE[2].RAM8x32.WORD[3].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[5] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[3].W.B0.BIT[6].LATCH SLICE[0].RAM8x32.Di[6]
+ SLICE[2].RAM8x32.WORD[3].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[3].W.B0.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[3].W.B0.BIT[6].OBUF
+ SLICE[2].RAM8x32.WORD[3].W.B0.q_wire[6] SLICE[2].RAM8x32.WORD[3].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[6] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[3].W.B0.BIT[7].LATCH SLICE[0].RAM8x32.Di[7]
+ SLICE[2].RAM8x32.WORD[3].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[3].W.B0.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[3].W.B0.BIT[7].OBUF
+ SLICE[2].RAM8x32.WORD[3].W.B0.q_wire[7] SLICE[2].RAM8x32.WORD[3].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[7] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[3].W.B0.CG SLICE[2].RAM8x32.WORD[3].W.B0.CLK_B
+ SLICE[2].RAM8x32.WORD[3].W.B0.we_wire VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[3].W.B0.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[2].RAM8x32.WORD[3].W.B0.CGAND SLICE[2].RAM8x32.WORD[3].W.B0.SEL
+ SLICE[2].RAM8x32.WORD[0].W.B0.WE VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[3].W.B0.we_wire sky130_fd_sc_hd__and2_1
XSLICE[2].RAM8x32.WORD[3].W.B0.CLKINV SLICE[2].RAM8x32.WORD[3].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[3].W.B0.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[3].W.B0.SELINV SLICE[2].RAM8x32.WORD[3].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[3].W.B0.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[3].W.B1.BIT[0].LATCH SLICE[0].RAM8x32.Di[8]
+ SLICE[2].RAM8x32.WORD[3].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[3].W.B1.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[3].W.B1.BIT[0].OBUF
+ SLICE[2].RAM8x32.WORD[3].W.B1.q_wire[0] SLICE[2].RAM8x32.WORD[3].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[8] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[3].W.B1.BIT[1].LATCH SLICE[0].RAM8x32.Di[9]
+ SLICE[2].RAM8x32.WORD[3].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[3].W.B1.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[3].W.B1.BIT[1].OBUF
+ SLICE[2].RAM8x32.WORD[3].W.B1.q_wire[1] SLICE[2].RAM8x32.WORD[3].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[9] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[3].W.B1.BIT[2].LATCH SLICE[0].RAM8x32.Di[10]
+ SLICE[2].RAM8x32.WORD[3].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[3].W.B1.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[3].W.B1.BIT[2].OBUF
+ SLICE[2].RAM8x32.WORD[3].W.B1.q_wire[2] SLICE[2].RAM8x32.WORD[3].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[10] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[3].W.B1.BIT[3].LATCH SLICE[0].RAM8x32.Di[11]
+ SLICE[2].RAM8x32.WORD[3].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[3].W.B1.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[3].W.B1.BIT[3].OBUF
+ SLICE[2].RAM8x32.WORD[3].W.B1.q_wire[3] SLICE[2].RAM8x32.WORD[3].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[11] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[3].W.B1.BIT[4].LATCH SLICE[0].RAM8x32.Di[12]
+ SLICE[2].RAM8x32.WORD[3].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[3].W.B1.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[3].W.B1.BIT[4].OBUF
+ SLICE[2].RAM8x32.WORD[3].W.B1.q_wire[4] SLICE[2].RAM8x32.WORD[3].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[12] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[3].W.B1.BIT[5].LATCH SLICE[0].RAM8x32.Di[13]
+ SLICE[2].RAM8x32.WORD[3].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[3].W.B1.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[3].W.B1.BIT[5].OBUF
+ SLICE[2].RAM8x32.WORD[3].W.B1.q_wire[5] SLICE[2].RAM8x32.WORD[3].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[13] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[3].W.B1.BIT[6].LATCH SLICE[0].RAM8x32.Di[14]
+ SLICE[2].RAM8x32.WORD[3].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[3].W.B1.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[3].W.B1.BIT[6].OBUF
+ SLICE[2].RAM8x32.WORD[3].W.B1.q_wire[6] SLICE[2].RAM8x32.WORD[3].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[14] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[3].W.B1.BIT[7].LATCH SLICE[0].RAM8x32.Di[15]
+ SLICE[2].RAM8x32.WORD[3].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[3].W.B1.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[3].W.B1.BIT[7].OBUF
+ SLICE[2].RAM8x32.WORD[3].W.B1.q_wire[7] SLICE[2].RAM8x32.WORD[3].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[15] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[3].W.B1.CG SLICE[2].RAM8x32.WORD[3].W.B1.CLK_B
+ SLICE[2].RAM8x32.WORD[3].W.B1.we_wire VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[3].W.B1.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[2].RAM8x32.WORD[3].W.B1.CGAND SLICE[2].RAM8x32.WORD[3].W.B0.SEL
+ SLICE[2].RAM8x32.WORD[0].W.B1.WE VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[3].W.B1.we_wire sky130_fd_sc_hd__and2_1
XSLICE[2].RAM8x32.WORD[3].W.B1.CLKINV SLICE[2].RAM8x32.WORD[3].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[3].W.B1.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[3].W.B1.SELINV SLICE[2].RAM8x32.WORD[3].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[3].W.B1.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[3].W.B2.BIT[0].LATCH SLICE[0].RAM8x32.Di[16]
+ SLICE[2].RAM8x32.WORD[3].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[3].W.B2.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[3].W.B2.BIT[0].OBUF
+ SLICE[2].RAM8x32.WORD[3].W.B2.q_wire[0] SLICE[2].RAM8x32.WORD[3].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[16] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[3].W.B2.BIT[1].LATCH SLICE[0].RAM8x32.Di[17]
+ SLICE[2].RAM8x32.WORD[3].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[3].W.B2.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[3].W.B2.BIT[1].OBUF
+ SLICE[2].RAM8x32.WORD[3].W.B2.q_wire[1] SLICE[2].RAM8x32.WORD[3].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[17] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[3].W.B2.BIT[2].LATCH SLICE[0].RAM8x32.Di[18]
+ SLICE[2].RAM8x32.WORD[3].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[3].W.B2.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[3].W.B2.BIT[2].OBUF
+ SLICE[2].RAM8x32.WORD[3].W.B2.q_wire[2] SLICE[2].RAM8x32.WORD[3].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[18] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[3].W.B2.BIT[3].LATCH SLICE[0].RAM8x32.Di[19]
+ SLICE[2].RAM8x32.WORD[3].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[3].W.B2.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[3].W.B2.BIT[3].OBUF
+ SLICE[2].RAM8x32.WORD[3].W.B2.q_wire[3] SLICE[2].RAM8x32.WORD[3].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[19] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[3].W.B2.BIT[4].LATCH SLICE[0].RAM8x32.Di[20]
+ SLICE[2].RAM8x32.WORD[3].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[3].W.B2.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[3].W.B2.BIT[4].OBUF
+ SLICE[2].RAM8x32.WORD[3].W.B2.q_wire[4] SLICE[2].RAM8x32.WORD[3].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[20] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[3].W.B2.BIT[5].LATCH SLICE[0].RAM8x32.Di[21]
+ SLICE[2].RAM8x32.WORD[3].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[3].W.B2.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[3].W.B2.BIT[5].OBUF
+ SLICE[2].RAM8x32.WORD[3].W.B2.q_wire[5] SLICE[2].RAM8x32.WORD[3].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[21] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[3].W.B2.BIT[6].LATCH SLICE[0].RAM8x32.Di[22]
+ SLICE[2].RAM8x32.WORD[3].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[3].W.B2.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[3].W.B2.BIT[6].OBUF
+ SLICE[2].RAM8x32.WORD[3].W.B2.q_wire[6] SLICE[2].RAM8x32.WORD[3].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[22] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[3].W.B2.BIT[7].LATCH SLICE[0].RAM8x32.Di[23]
+ SLICE[2].RAM8x32.WORD[3].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[3].W.B2.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[3].W.B2.BIT[7].OBUF
+ SLICE[2].RAM8x32.WORD[3].W.B2.q_wire[7] SLICE[2].RAM8x32.WORD[3].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[23] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[3].W.B2.CG SLICE[2].RAM8x32.WORD[3].W.B2.CLK_B
+ SLICE[2].RAM8x32.WORD[3].W.B2.we_wire VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[3].W.B2.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[2].RAM8x32.WORD[3].W.B2.CGAND SLICE[2].RAM8x32.WORD[3].W.B0.SEL
+ SLICE[2].RAM8x32.WORD[0].W.B2.WE VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[3].W.B2.we_wire sky130_fd_sc_hd__and2_1
XSLICE[2].RAM8x32.WORD[3].W.B2.CLKINV SLICE[2].RAM8x32.WORD[3].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[3].W.B2.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[3].W.B2.SELINV SLICE[2].RAM8x32.WORD[3].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[3].W.B2.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[3].W.B3.BIT[0].LATCH SLICE[0].RAM8x32.Di[24]
+ SLICE[2].RAM8x32.WORD[3].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[3].W.B3.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[3].W.B3.BIT[0].OBUF
+ SLICE[2].RAM8x32.WORD[3].W.B3.q_wire[0] SLICE[2].RAM8x32.WORD[3].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[24] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[3].W.B3.BIT[1].LATCH SLICE[0].RAM8x32.Di[25]
+ SLICE[2].RAM8x32.WORD[3].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[3].W.B3.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[3].W.B3.BIT[1].OBUF
+ SLICE[2].RAM8x32.WORD[3].W.B3.q_wire[1] SLICE[2].RAM8x32.WORD[3].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[25] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[3].W.B3.BIT[2].LATCH SLICE[0].RAM8x32.Di[26]
+ SLICE[2].RAM8x32.WORD[3].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[3].W.B3.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[3].W.B3.BIT[2].OBUF
+ SLICE[2].RAM8x32.WORD[3].W.B3.q_wire[2] SLICE[2].RAM8x32.WORD[3].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[26] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[3].W.B3.BIT[3].LATCH SLICE[0].RAM8x32.Di[27]
+ SLICE[2].RAM8x32.WORD[3].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[3].W.B3.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[3].W.B3.BIT[3].OBUF
+ SLICE[2].RAM8x32.WORD[3].W.B3.q_wire[3] SLICE[2].RAM8x32.WORD[3].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[27] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[3].W.B3.BIT[4].LATCH SLICE[0].RAM8x32.Di[28]
+ SLICE[2].RAM8x32.WORD[3].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[3].W.B3.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[3].W.B3.BIT[4].OBUF
+ SLICE[2].RAM8x32.WORD[3].W.B3.q_wire[4] SLICE[2].RAM8x32.WORD[3].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[28] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[3].W.B3.BIT[5].LATCH SLICE[0].RAM8x32.Di[29]
+ SLICE[2].RAM8x32.WORD[3].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[3].W.B3.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[3].W.B3.BIT[5].OBUF
+ SLICE[2].RAM8x32.WORD[3].W.B3.q_wire[5] SLICE[2].RAM8x32.WORD[3].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[29] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[3].W.B3.BIT[6].LATCH SLICE[0].RAM8x32.Di[30]
+ SLICE[2].RAM8x32.WORD[3].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[3].W.B3.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[3].W.B3.BIT[6].OBUF
+ SLICE[2].RAM8x32.WORD[3].W.B3.q_wire[6] SLICE[2].RAM8x32.WORD[3].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[30] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[3].W.B3.BIT[7].LATCH SLICE[0].RAM8x32.Di[31]
+ SLICE[2].RAM8x32.WORD[3].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[3].W.B3.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[3].W.B3.BIT[7].OBUF
+ SLICE[2].RAM8x32.WORD[3].W.B3.q_wire[7] SLICE[2].RAM8x32.WORD[3].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[31] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[3].W.B3.CG SLICE[2].RAM8x32.WORD[3].W.B3.CLK_B
+ SLICE[2].RAM8x32.WORD[3].W.B3.we_wire VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[3].W.B3.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[2].RAM8x32.WORD[3].W.B3.CGAND SLICE[2].RAM8x32.WORD[3].W.B0.SEL
+ SLICE[2].RAM8x32.WORD[0].W.B3.WE VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[3].W.B3.we_wire sky130_fd_sc_hd__and2_1
XSLICE[2].RAM8x32.WORD[3].W.B3.CLKINV SLICE[2].RAM8x32.WORD[3].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[3].W.B3.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[3].W.B3.SELINV SLICE[2].RAM8x32.WORD[3].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[3].W.B3.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[3].W.CLKBUF SLICE[2].RAM8x32.CLK_buf VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[3].W.B0.CLK sky130_fd_sc_hd__clkbuf_1
XSLICE[2].RAM8x32.WORD[3].W.SELBUF SLICE[2].RAM8x32.WORD[3].W.SEL VGND VGND
+ VPWR VPWR SLICE[2].RAM8x32.WORD[3].W.B0.SEL sky130_fd_sc_hd__clkbuf_2
XSLICE[2].RAM8x32.WORD[4].W.B0.BIT[0].LATCH SLICE[0].RAM8x32.Di[0]
+ SLICE[2].RAM8x32.WORD[4].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[4].W.B0.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[4].W.B0.BIT[0].OBUF
+ SLICE[2].RAM8x32.WORD[4].W.B0.q_wire[0] SLICE[2].RAM8x32.WORD[4].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[0] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[4].W.B0.BIT[1].LATCH SLICE[0].RAM8x32.Di[1]
+ SLICE[2].RAM8x32.WORD[4].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[4].W.B0.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[4].W.B0.BIT[1].OBUF
+ SLICE[2].RAM8x32.WORD[4].W.B0.q_wire[1] SLICE[2].RAM8x32.WORD[4].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[1] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[4].W.B0.BIT[2].LATCH SLICE[0].RAM8x32.Di[2]
+ SLICE[2].RAM8x32.WORD[4].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[4].W.B0.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[4].W.B0.BIT[2].OBUF
+ SLICE[2].RAM8x32.WORD[4].W.B0.q_wire[2] SLICE[2].RAM8x32.WORD[4].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[2] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[4].W.B0.BIT[3].LATCH SLICE[0].RAM8x32.Di[3]
+ SLICE[2].RAM8x32.WORD[4].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[4].W.B0.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[4].W.B0.BIT[3].OBUF
+ SLICE[2].RAM8x32.WORD[4].W.B0.q_wire[3] SLICE[2].RAM8x32.WORD[4].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[3] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[4].W.B0.BIT[4].LATCH SLICE[0].RAM8x32.Di[4]
+ SLICE[2].RAM8x32.WORD[4].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[4].W.B0.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[4].W.B0.BIT[4].OBUF
+ SLICE[2].RAM8x32.WORD[4].W.B0.q_wire[4] SLICE[2].RAM8x32.WORD[4].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[4] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[4].W.B0.BIT[5].LATCH SLICE[0].RAM8x32.Di[5]
+ SLICE[2].RAM8x32.WORD[4].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[4].W.B0.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[4].W.B0.BIT[5].OBUF
+ SLICE[2].RAM8x32.WORD[4].W.B0.q_wire[5] SLICE[2].RAM8x32.WORD[4].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[5] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[4].W.B0.BIT[6].LATCH SLICE[0].RAM8x32.Di[6]
+ SLICE[2].RAM8x32.WORD[4].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[4].W.B0.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[4].W.B0.BIT[6].OBUF
+ SLICE[2].RAM8x32.WORD[4].W.B0.q_wire[6] SLICE[2].RAM8x32.WORD[4].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[6] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[4].W.B0.BIT[7].LATCH SLICE[0].RAM8x32.Di[7]
+ SLICE[2].RAM8x32.WORD[4].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[4].W.B0.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[4].W.B0.BIT[7].OBUF
+ SLICE[2].RAM8x32.WORD[4].W.B0.q_wire[7] SLICE[2].RAM8x32.WORD[4].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[7] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[4].W.B0.CG SLICE[2].RAM8x32.WORD[4].W.B0.CLK_B
+ SLICE[2].RAM8x32.WORD[4].W.B0.we_wire VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[4].W.B0.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[2].RAM8x32.WORD[4].W.B0.CGAND SLICE[2].RAM8x32.WORD[4].W.B0.SEL
+ SLICE[2].RAM8x32.WORD[0].W.B0.WE VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[4].W.B0.we_wire sky130_fd_sc_hd__and2_1
XSLICE[2].RAM8x32.WORD[4].W.B0.CLKINV SLICE[2].RAM8x32.WORD[4].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[4].W.B0.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[4].W.B0.SELINV SLICE[2].RAM8x32.WORD[4].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[4].W.B0.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[4].W.B1.BIT[0].LATCH SLICE[0].RAM8x32.Di[8]
+ SLICE[2].RAM8x32.WORD[4].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[4].W.B1.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[4].W.B1.BIT[0].OBUF
+ SLICE[2].RAM8x32.WORD[4].W.B1.q_wire[0] SLICE[2].RAM8x32.WORD[4].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[8] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[4].W.B1.BIT[1].LATCH SLICE[0].RAM8x32.Di[9]
+ SLICE[2].RAM8x32.WORD[4].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[4].W.B1.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[4].W.B1.BIT[1].OBUF
+ SLICE[2].RAM8x32.WORD[4].W.B1.q_wire[1] SLICE[2].RAM8x32.WORD[4].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[9] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[4].W.B1.BIT[2].LATCH SLICE[0].RAM8x32.Di[10]
+ SLICE[2].RAM8x32.WORD[4].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[4].W.B1.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[4].W.B1.BIT[2].OBUF
+ SLICE[2].RAM8x32.WORD[4].W.B1.q_wire[2] SLICE[2].RAM8x32.WORD[4].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[10] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[4].W.B1.BIT[3].LATCH SLICE[0].RAM8x32.Di[11]
+ SLICE[2].RAM8x32.WORD[4].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[4].W.B1.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[4].W.B1.BIT[3].OBUF
+ SLICE[2].RAM8x32.WORD[4].W.B1.q_wire[3] SLICE[2].RAM8x32.WORD[4].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[11] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[4].W.B1.BIT[4].LATCH SLICE[0].RAM8x32.Di[12]
+ SLICE[2].RAM8x32.WORD[4].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[4].W.B1.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[4].W.B1.BIT[4].OBUF
+ SLICE[2].RAM8x32.WORD[4].W.B1.q_wire[4] SLICE[2].RAM8x32.WORD[4].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[12] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[4].W.B1.BIT[5].LATCH SLICE[0].RAM8x32.Di[13]
+ SLICE[2].RAM8x32.WORD[4].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[4].W.B1.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[4].W.B1.BIT[5].OBUF
+ SLICE[2].RAM8x32.WORD[4].W.B1.q_wire[5] SLICE[2].RAM8x32.WORD[4].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[13] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[4].W.B1.BIT[6].LATCH SLICE[0].RAM8x32.Di[14]
+ SLICE[2].RAM8x32.WORD[4].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[4].W.B1.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[4].W.B1.BIT[6].OBUF
+ SLICE[2].RAM8x32.WORD[4].W.B1.q_wire[6] SLICE[2].RAM8x32.WORD[4].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[14] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[4].W.B1.BIT[7].LATCH SLICE[0].RAM8x32.Di[15]
+ SLICE[2].RAM8x32.WORD[4].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[4].W.B1.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[4].W.B1.BIT[7].OBUF
+ SLICE[2].RAM8x32.WORD[4].W.B1.q_wire[7] SLICE[2].RAM8x32.WORD[4].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[15] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[4].W.B1.CG SLICE[2].RAM8x32.WORD[4].W.B1.CLK_B
+ SLICE[2].RAM8x32.WORD[4].W.B1.we_wire VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[4].W.B1.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[2].RAM8x32.WORD[4].W.B1.CGAND SLICE[2].RAM8x32.WORD[4].W.B0.SEL
+ SLICE[2].RAM8x32.WORD[0].W.B1.WE VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[4].W.B1.we_wire sky130_fd_sc_hd__and2_1
XSLICE[2].RAM8x32.WORD[4].W.B1.CLKINV SLICE[2].RAM8x32.WORD[4].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[4].W.B1.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[4].W.B1.SELINV SLICE[2].RAM8x32.WORD[4].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[4].W.B1.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[4].W.B2.BIT[0].LATCH SLICE[0].RAM8x32.Di[16]
+ SLICE[2].RAM8x32.WORD[4].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[4].W.B2.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[4].W.B2.BIT[0].OBUF
+ SLICE[2].RAM8x32.WORD[4].W.B2.q_wire[0] SLICE[2].RAM8x32.WORD[4].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[16] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[4].W.B2.BIT[1].LATCH SLICE[0].RAM8x32.Di[17]
+ SLICE[2].RAM8x32.WORD[4].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[4].W.B2.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[4].W.B2.BIT[1].OBUF
+ SLICE[2].RAM8x32.WORD[4].W.B2.q_wire[1] SLICE[2].RAM8x32.WORD[4].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[17] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[4].W.B2.BIT[2].LATCH SLICE[0].RAM8x32.Di[18]
+ SLICE[2].RAM8x32.WORD[4].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[4].W.B2.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[4].W.B2.BIT[2].OBUF
+ SLICE[2].RAM8x32.WORD[4].W.B2.q_wire[2] SLICE[2].RAM8x32.WORD[4].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[18] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[4].W.B2.BIT[3].LATCH SLICE[0].RAM8x32.Di[19]
+ SLICE[2].RAM8x32.WORD[4].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[4].W.B2.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[4].W.B2.BIT[3].OBUF
+ SLICE[2].RAM8x32.WORD[4].W.B2.q_wire[3] SLICE[2].RAM8x32.WORD[4].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[19] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[4].W.B2.BIT[4].LATCH SLICE[0].RAM8x32.Di[20]
+ SLICE[2].RAM8x32.WORD[4].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[4].W.B2.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[4].W.B2.BIT[4].OBUF
+ SLICE[2].RAM8x32.WORD[4].W.B2.q_wire[4] SLICE[2].RAM8x32.WORD[4].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[20] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[4].W.B2.BIT[5].LATCH SLICE[0].RAM8x32.Di[21]
+ SLICE[2].RAM8x32.WORD[4].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[4].W.B2.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[4].W.B2.BIT[5].OBUF
+ SLICE[2].RAM8x32.WORD[4].W.B2.q_wire[5] SLICE[2].RAM8x32.WORD[4].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[21] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[4].W.B2.BIT[6].LATCH SLICE[0].RAM8x32.Di[22]
+ SLICE[2].RAM8x32.WORD[4].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[4].W.B2.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[4].W.B2.BIT[6].OBUF
+ SLICE[2].RAM8x32.WORD[4].W.B2.q_wire[6] SLICE[2].RAM8x32.WORD[4].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[22] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[4].W.B2.BIT[7].LATCH SLICE[0].RAM8x32.Di[23]
+ SLICE[2].RAM8x32.WORD[4].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[4].W.B2.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[4].W.B2.BIT[7].OBUF
+ SLICE[2].RAM8x32.WORD[4].W.B2.q_wire[7] SLICE[2].RAM8x32.WORD[4].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[23] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[4].W.B2.CG SLICE[2].RAM8x32.WORD[4].W.B2.CLK_B
+ SLICE[2].RAM8x32.WORD[4].W.B2.we_wire VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[4].W.B2.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[2].RAM8x32.WORD[4].W.B2.CGAND SLICE[2].RAM8x32.WORD[4].W.B0.SEL
+ SLICE[2].RAM8x32.WORD[0].W.B2.WE VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[4].W.B2.we_wire sky130_fd_sc_hd__and2_1
XSLICE[2].RAM8x32.WORD[4].W.B2.CLKINV SLICE[2].RAM8x32.WORD[4].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[4].W.B2.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[4].W.B2.SELINV SLICE[2].RAM8x32.WORD[4].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[4].W.B2.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[4].W.B3.BIT[0].LATCH SLICE[0].RAM8x32.Di[24]
+ SLICE[2].RAM8x32.WORD[4].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[4].W.B3.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[4].W.B3.BIT[0].OBUF
+ SLICE[2].RAM8x32.WORD[4].W.B3.q_wire[0] SLICE[2].RAM8x32.WORD[4].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[24] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[4].W.B3.BIT[1].LATCH SLICE[0].RAM8x32.Di[25]
+ SLICE[2].RAM8x32.WORD[4].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[4].W.B3.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[4].W.B3.BIT[1].OBUF
+ SLICE[2].RAM8x32.WORD[4].W.B3.q_wire[1] SLICE[2].RAM8x32.WORD[4].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[25] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[4].W.B3.BIT[2].LATCH SLICE[0].RAM8x32.Di[26]
+ SLICE[2].RAM8x32.WORD[4].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[4].W.B3.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[4].W.B3.BIT[2].OBUF
+ SLICE[2].RAM8x32.WORD[4].W.B3.q_wire[2] SLICE[2].RAM8x32.WORD[4].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[26] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[4].W.B3.BIT[3].LATCH SLICE[0].RAM8x32.Di[27]
+ SLICE[2].RAM8x32.WORD[4].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[4].W.B3.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[4].W.B3.BIT[3].OBUF
+ SLICE[2].RAM8x32.WORD[4].W.B3.q_wire[3] SLICE[2].RAM8x32.WORD[4].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[27] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[4].W.B3.BIT[4].LATCH SLICE[0].RAM8x32.Di[28]
+ SLICE[2].RAM8x32.WORD[4].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[4].W.B3.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[4].W.B3.BIT[4].OBUF
+ SLICE[2].RAM8x32.WORD[4].W.B3.q_wire[4] SLICE[2].RAM8x32.WORD[4].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[28] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[4].W.B3.BIT[5].LATCH SLICE[0].RAM8x32.Di[29]
+ SLICE[2].RAM8x32.WORD[4].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[4].W.B3.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[4].W.B3.BIT[5].OBUF
+ SLICE[2].RAM8x32.WORD[4].W.B3.q_wire[5] SLICE[2].RAM8x32.WORD[4].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[29] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[4].W.B3.BIT[6].LATCH SLICE[0].RAM8x32.Di[30]
+ SLICE[2].RAM8x32.WORD[4].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[4].W.B3.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[4].W.B3.BIT[6].OBUF
+ SLICE[2].RAM8x32.WORD[4].W.B3.q_wire[6] SLICE[2].RAM8x32.WORD[4].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[30] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[4].W.B3.BIT[7].LATCH SLICE[0].RAM8x32.Di[31]
+ SLICE[2].RAM8x32.WORD[4].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[4].W.B3.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[4].W.B3.BIT[7].OBUF
+ SLICE[2].RAM8x32.WORD[4].W.B3.q_wire[7] SLICE[2].RAM8x32.WORD[4].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[31] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[4].W.B3.CG SLICE[2].RAM8x32.WORD[4].W.B3.CLK_B
+ SLICE[2].RAM8x32.WORD[4].W.B3.we_wire VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[4].W.B3.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[2].RAM8x32.WORD[4].W.B3.CGAND SLICE[2].RAM8x32.WORD[4].W.B0.SEL
+ SLICE[2].RAM8x32.WORD[0].W.B3.WE VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[4].W.B3.we_wire sky130_fd_sc_hd__and2_1
XSLICE[2].RAM8x32.WORD[4].W.B3.CLKINV SLICE[2].RAM8x32.WORD[4].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[4].W.B3.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[4].W.B3.SELINV SLICE[2].RAM8x32.WORD[4].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[4].W.B3.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[4].W.CLKBUF SLICE[2].RAM8x32.CLK_buf VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[4].W.B0.CLK sky130_fd_sc_hd__clkbuf_1
XSLICE[2].RAM8x32.WORD[4].W.SELBUF SLICE[2].RAM8x32.WORD[4].W.SEL VGND VGND
+ VPWR VPWR SLICE[2].RAM8x32.WORD[4].W.B0.SEL sky130_fd_sc_hd__clkbuf_2
XSLICE[2].RAM8x32.WORD[5].W.B0.BIT[0].LATCH SLICE[0].RAM8x32.Di[0]
+ SLICE[2].RAM8x32.WORD[5].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[5].W.B0.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[5].W.B0.BIT[0].OBUF
+ SLICE[2].RAM8x32.WORD[5].W.B0.q_wire[0] SLICE[2].RAM8x32.WORD[5].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[0] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[5].W.B0.BIT[1].LATCH SLICE[0].RAM8x32.Di[1]
+ SLICE[2].RAM8x32.WORD[5].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[5].W.B0.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[5].W.B0.BIT[1].OBUF
+ SLICE[2].RAM8x32.WORD[5].W.B0.q_wire[1] SLICE[2].RAM8x32.WORD[5].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[1] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[5].W.B0.BIT[2].LATCH SLICE[0].RAM8x32.Di[2]
+ SLICE[2].RAM8x32.WORD[5].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[5].W.B0.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[5].W.B0.BIT[2].OBUF
+ SLICE[2].RAM8x32.WORD[5].W.B0.q_wire[2] SLICE[2].RAM8x32.WORD[5].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[2] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[5].W.B0.BIT[3].LATCH SLICE[0].RAM8x32.Di[3]
+ SLICE[2].RAM8x32.WORD[5].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[5].W.B0.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[5].W.B0.BIT[3].OBUF
+ SLICE[2].RAM8x32.WORD[5].W.B0.q_wire[3] SLICE[2].RAM8x32.WORD[5].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[3] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[5].W.B0.BIT[4].LATCH SLICE[0].RAM8x32.Di[4]
+ SLICE[2].RAM8x32.WORD[5].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[5].W.B0.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[5].W.B0.BIT[4].OBUF
+ SLICE[2].RAM8x32.WORD[5].W.B0.q_wire[4] SLICE[2].RAM8x32.WORD[5].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[4] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[5].W.B0.BIT[5].LATCH SLICE[0].RAM8x32.Di[5]
+ SLICE[2].RAM8x32.WORD[5].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[5].W.B0.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[5].W.B0.BIT[5].OBUF
+ SLICE[2].RAM8x32.WORD[5].W.B0.q_wire[5] SLICE[2].RAM8x32.WORD[5].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[5] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[5].W.B0.BIT[6].LATCH SLICE[0].RAM8x32.Di[6]
+ SLICE[2].RAM8x32.WORD[5].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[5].W.B0.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[5].W.B0.BIT[6].OBUF
+ SLICE[2].RAM8x32.WORD[5].W.B0.q_wire[6] SLICE[2].RAM8x32.WORD[5].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[6] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[5].W.B0.BIT[7].LATCH SLICE[0].RAM8x32.Di[7]
+ SLICE[2].RAM8x32.WORD[5].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[5].W.B0.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[5].W.B0.BIT[7].OBUF
+ SLICE[2].RAM8x32.WORD[5].W.B0.q_wire[7] SLICE[2].RAM8x32.WORD[5].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[7] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[5].W.B0.CG SLICE[2].RAM8x32.WORD[5].W.B0.CLK_B
+ SLICE[2].RAM8x32.WORD[5].W.B0.we_wire VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[5].W.B0.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[2].RAM8x32.WORD[5].W.B0.CGAND SLICE[2].RAM8x32.WORD[5].W.B0.SEL
+ SLICE[2].RAM8x32.WORD[0].W.B0.WE VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[5].W.B0.we_wire sky130_fd_sc_hd__and2_1
XSLICE[2].RAM8x32.WORD[5].W.B0.CLKINV SLICE[2].RAM8x32.WORD[5].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[5].W.B0.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[5].W.B0.SELINV SLICE[2].RAM8x32.WORD[5].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[5].W.B0.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[5].W.B1.BIT[0].LATCH SLICE[0].RAM8x32.Di[8]
+ SLICE[2].RAM8x32.WORD[5].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[5].W.B1.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[5].W.B1.BIT[0].OBUF
+ SLICE[2].RAM8x32.WORD[5].W.B1.q_wire[0] SLICE[2].RAM8x32.WORD[5].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[8] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[5].W.B1.BIT[1].LATCH SLICE[0].RAM8x32.Di[9]
+ SLICE[2].RAM8x32.WORD[5].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[5].W.B1.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[5].W.B1.BIT[1].OBUF
+ SLICE[2].RAM8x32.WORD[5].W.B1.q_wire[1] SLICE[2].RAM8x32.WORD[5].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[9] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[5].W.B1.BIT[2].LATCH SLICE[0].RAM8x32.Di[10]
+ SLICE[2].RAM8x32.WORD[5].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[5].W.B1.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[5].W.B1.BIT[2].OBUF
+ SLICE[2].RAM8x32.WORD[5].W.B1.q_wire[2] SLICE[2].RAM8x32.WORD[5].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[10] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[5].W.B1.BIT[3].LATCH SLICE[0].RAM8x32.Di[11]
+ SLICE[2].RAM8x32.WORD[5].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[5].W.B1.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[5].W.B1.BIT[3].OBUF
+ SLICE[2].RAM8x32.WORD[5].W.B1.q_wire[3] SLICE[2].RAM8x32.WORD[5].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[11] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[5].W.B1.BIT[4].LATCH SLICE[0].RAM8x32.Di[12]
+ SLICE[2].RAM8x32.WORD[5].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[5].W.B1.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[5].W.B1.BIT[4].OBUF
+ SLICE[2].RAM8x32.WORD[5].W.B1.q_wire[4] SLICE[2].RAM8x32.WORD[5].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[12] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[5].W.B1.BIT[5].LATCH SLICE[0].RAM8x32.Di[13]
+ SLICE[2].RAM8x32.WORD[5].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[5].W.B1.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[5].W.B1.BIT[5].OBUF
+ SLICE[2].RAM8x32.WORD[5].W.B1.q_wire[5] SLICE[2].RAM8x32.WORD[5].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[13] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[5].W.B1.BIT[6].LATCH SLICE[0].RAM8x32.Di[14]
+ SLICE[2].RAM8x32.WORD[5].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[5].W.B1.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[5].W.B1.BIT[6].OBUF
+ SLICE[2].RAM8x32.WORD[5].W.B1.q_wire[6] SLICE[2].RAM8x32.WORD[5].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[14] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[5].W.B1.BIT[7].LATCH SLICE[0].RAM8x32.Di[15]
+ SLICE[2].RAM8x32.WORD[5].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[5].W.B1.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[5].W.B1.BIT[7].OBUF
+ SLICE[2].RAM8x32.WORD[5].W.B1.q_wire[7] SLICE[2].RAM8x32.WORD[5].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[15] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[5].W.B1.CG SLICE[2].RAM8x32.WORD[5].W.B1.CLK_B
+ SLICE[2].RAM8x32.WORD[5].W.B1.we_wire VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[5].W.B1.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[2].RAM8x32.WORD[5].W.B1.CGAND SLICE[2].RAM8x32.WORD[5].W.B0.SEL
+ SLICE[2].RAM8x32.WORD[0].W.B1.WE VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[5].W.B1.we_wire sky130_fd_sc_hd__and2_1
XSLICE[2].RAM8x32.WORD[5].W.B1.CLKINV SLICE[2].RAM8x32.WORD[5].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[5].W.B1.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[5].W.B1.SELINV SLICE[2].RAM8x32.WORD[5].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[5].W.B1.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[5].W.B2.BIT[0].LATCH SLICE[0].RAM8x32.Di[16]
+ SLICE[2].RAM8x32.WORD[5].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[5].W.B2.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[5].W.B2.BIT[0].OBUF
+ SLICE[2].RAM8x32.WORD[5].W.B2.q_wire[0] SLICE[2].RAM8x32.WORD[5].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[16] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[5].W.B2.BIT[1].LATCH SLICE[0].RAM8x32.Di[17]
+ SLICE[2].RAM8x32.WORD[5].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[5].W.B2.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[5].W.B2.BIT[1].OBUF
+ SLICE[2].RAM8x32.WORD[5].W.B2.q_wire[1] SLICE[2].RAM8x32.WORD[5].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[17] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[5].W.B2.BIT[2].LATCH SLICE[0].RAM8x32.Di[18]
+ SLICE[2].RAM8x32.WORD[5].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[5].W.B2.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[5].W.B2.BIT[2].OBUF
+ SLICE[2].RAM8x32.WORD[5].W.B2.q_wire[2] SLICE[2].RAM8x32.WORD[5].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[18] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[5].W.B2.BIT[3].LATCH SLICE[0].RAM8x32.Di[19]
+ SLICE[2].RAM8x32.WORD[5].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[5].W.B2.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[5].W.B2.BIT[3].OBUF
+ SLICE[2].RAM8x32.WORD[5].W.B2.q_wire[3] SLICE[2].RAM8x32.WORD[5].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[19] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[5].W.B2.BIT[4].LATCH SLICE[0].RAM8x32.Di[20]
+ SLICE[2].RAM8x32.WORD[5].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[5].W.B2.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[5].W.B2.BIT[4].OBUF
+ SLICE[2].RAM8x32.WORD[5].W.B2.q_wire[4] SLICE[2].RAM8x32.WORD[5].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[20] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[5].W.B2.BIT[5].LATCH SLICE[0].RAM8x32.Di[21]
+ SLICE[2].RAM8x32.WORD[5].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[5].W.B2.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[5].W.B2.BIT[5].OBUF
+ SLICE[2].RAM8x32.WORD[5].W.B2.q_wire[5] SLICE[2].RAM8x32.WORD[5].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[21] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[5].W.B2.BIT[6].LATCH SLICE[0].RAM8x32.Di[22]
+ SLICE[2].RAM8x32.WORD[5].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[5].W.B2.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[5].W.B2.BIT[6].OBUF
+ SLICE[2].RAM8x32.WORD[5].W.B2.q_wire[6] SLICE[2].RAM8x32.WORD[5].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[22] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[5].W.B2.BIT[7].LATCH SLICE[0].RAM8x32.Di[23]
+ SLICE[2].RAM8x32.WORD[5].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[5].W.B2.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[5].W.B2.BIT[7].OBUF
+ SLICE[2].RAM8x32.WORD[5].W.B2.q_wire[7] SLICE[2].RAM8x32.WORD[5].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[23] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[5].W.B2.CG SLICE[2].RAM8x32.WORD[5].W.B2.CLK_B
+ SLICE[2].RAM8x32.WORD[5].W.B2.we_wire VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[5].W.B2.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[2].RAM8x32.WORD[5].W.B2.CGAND SLICE[2].RAM8x32.WORD[5].W.B0.SEL
+ SLICE[2].RAM8x32.WORD[0].W.B2.WE VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[5].W.B2.we_wire sky130_fd_sc_hd__and2_1
XSLICE[2].RAM8x32.WORD[5].W.B2.CLKINV SLICE[2].RAM8x32.WORD[5].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[5].W.B2.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[5].W.B2.SELINV SLICE[2].RAM8x32.WORD[5].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[5].W.B2.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[5].W.B3.BIT[0].LATCH SLICE[0].RAM8x32.Di[24]
+ SLICE[2].RAM8x32.WORD[5].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[5].W.B3.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[5].W.B3.BIT[0].OBUF
+ SLICE[2].RAM8x32.WORD[5].W.B3.q_wire[0] SLICE[2].RAM8x32.WORD[5].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[24] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[5].W.B3.BIT[1].LATCH SLICE[0].RAM8x32.Di[25]
+ SLICE[2].RAM8x32.WORD[5].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[5].W.B3.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[5].W.B3.BIT[1].OBUF
+ SLICE[2].RAM8x32.WORD[5].W.B3.q_wire[1] SLICE[2].RAM8x32.WORD[5].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[25] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[5].W.B3.BIT[2].LATCH SLICE[0].RAM8x32.Di[26]
+ SLICE[2].RAM8x32.WORD[5].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[5].W.B3.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[5].W.B3.BIT[2].OBUF
+ SLICE[2].RAM8x32.WORD[5].W.B3.q_wire[2] SLICE[2].RAM8x32.WORD[5].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[26] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[5].W.B3.BIT[3].LATCH SLICE[0].RAM8x32.Di[27]
+ SLICE[2].RAM8x32.WORD[5].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[5].W.B3.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[5].W.B3.BIT[3].OBUF
+ SLICE[2].RAM8x32.WORD[5].W.B3.q_wire[3] SLICE[2].RAM8x32.WORD[5].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[27] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[5].W.B3.BIT[4].LATCH SLICE[0].RAM8x32.Di[28]
+ SLICE[2].RAM8x32.WORD[5].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[5].W.B3.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[5].W.B3.BIT[4].OBUF
+ SLICE[2].RAM8x32.WORD[5].W.B3.q_wire[4] SLICE[2].RAM8x32.WORD[5].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[28] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[5].W.B3.BIT[5].LATCH SLICE[0].RAM8x32.Di[29]
+ SLICE[2].RAM8x32.WORD[5].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[5].W.B3.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[5].W.B3.BIT[5].OBUF
+ SLICE[2].RAM8x32.WORD[5].W.B3.q_wire[5] SLICE[2].RAM8x32.WORD[5].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[29] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[5].W.B3.BIT[6].LATCH SLICE[0].RAM8x32.Di[30]
+ SLICE[2].RAM8x32.WORD[5].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[5].W.B3.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[5].W.B3.BIT[6].OBUF
+ SLICE[2].RAM8x32.WORD[5].W.B3.q_wire[6] SLICE[2].RAM8x32.WORD[5].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[30] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[5].W.B3.BIT[7].LATCH SLICE[0].RAM8x32.Di[31]
+ SLICE[2].RAM8x32.WORD[5].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[5].W.B3.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[5].W.B3.BIT[7].OBUF
+ SLICE[2].RAM8x32.WORD[5].W.B3.q_wire[7] SLICE[2].RAM8x32.WORD[5].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[31] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[5].W.B3.CG SLICE[2].RAM8x32.WORD[5].W.B3.CLK_B
+ SLICE[2].RAM8x32.WORD[5].W.B3.we_wire VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[5].W.B3.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[2].RAM8x32.WORD[5].W.B3.CGAND SLICE[2].RAM8x32.WORD[5].W.B0.SEL
+ SLICE[2].RAM8x32.WORD[0].W.B3.WE VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[5].W.B3.we_wire sky130_fd_sc_hd__and2_1
XSLICE[2].RAM8x32.WORD[5].W.B3.CLKINV SLICE[2].RAM8x32.WORD[5].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[5].W.B3.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[5].W.B3.SELINV SLICE[2].RAM8x32.WORD[5].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[5].W.B3.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[5].W.CLKBUF SLICE[2].RAM8x32.CLK_buf VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[5].W.B0.CLK sky130_fd_sc_hd__clkbuf_1
XSLICE[2].RAM8x32.WORD[5].W.SELBUF SLICE[2].RAM8x32.WORD[5].W.SEL VGND VGND
+ VPWR VPWR SLICE[2].RAM8x32.WORD[5].W.B0.SEL sky130_fd_sc_hd__clkbuf_2
XSLICE[2].RAM8x32.WORD[6].W.B0.BIT[0].LATCH SLICE[0].RAM8x32.Di[0]
+ SLICE[2].RAM8x32.WORD[6].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[6].W.B0.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[6].W.B0.BIT[0].OBUF
+ SLICE[2].RAM8x32.WORD[6].W.B0.q_wire[0] SLICE[2].RAM8x32.WORD[6].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[0] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[6].W.B0.BIT[1].LATCH SLICE[0].RAM8x32.Di[1]
+ SLICE[2].RAM8x32.WORD[6].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[6].W.B0.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[6].W.B0.BIT[1].OBUF
+ SLICE[2].RAM8x32.WORD[6].W.B0.q_wire[1] SLICE[2].RAM8x32.WORD[6].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[1] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[6].W.B0.BIT[2].LATCH SLICE[0].RAM8x32.Di[2]
+ SLICE[2].RAM8x32.WORD[6].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[6].W.B0.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[6].W.B0.BIT[2].OBUF
+ SLICE[2].RAM8x32.WORD[6].W.B0.q_wire[2] SLICE[2].RAM8x32.WORD[6].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[2] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[6].W.B0.BIT[3].LATCH SLICE[0].RAM8x32.Di[3]
+ SLICE[2].RAM8x32.WORD[6].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[6].W.B0.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[6].W.B0.BIT[3].OBUF
+ SLICE[2].RAM8x32.WORD[6].W.B0.q_wire[3] SLICE[2].RAM8x32.WORD[6].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[3] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[6].W.B0.BIT[4].LATCH SLICE[0].RAM8x32.Di[4]
+ SLICE[2].RAM8x32.WORD[6].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[6].W.B0.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[6].W.B0.BIT[4].OBUF
+ SLICE[2].RAM8x32.WORD[6].W.B0.q_wire[4] SLICE[2].RAM8x32.WORD[6].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[4] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[6].W.B0.BIT[5].LATCH SLICE[0].RAM8x32.Di[5]
+ SLICE[2].RAM8x32.WORD[6].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[6].W.B0.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[6].W.B0.BIT[5].OBUF
+ SLICE[2].RAM8x32.WORD[6].W.B0.q_wire[5] SLICE[2].RAM8x32.WORD[6].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[5] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[6].W.B0.BIT[6].LATCH SLICE[0].RAM8x32.Di[6]
+ SLICE[2].RAM8x32.WORD[6].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[6].W.B0.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[6].W.B0.BIT[6].OBUF
+ SLICE[2].RAM8x32.WORD[6].W.B0.q_wire[6] SLICE[2].RAM8x32.WORD[6].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[6] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[6].W.B0.BIT[7].LATCH SLICE[0].RAM8x32.Di[7]
+ SLICE[2].RAM8x32.WORD[6].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[6].W.B0.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[6].W.B0.BIT[7].OBUF
+ SLICE[2].RAM8x32.WORD[6].W.B0.q_wire[7] SLICE[2].RAM8x32.WORD[6].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[7] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[6].W.B0.CG SLICE[2].RAM8x32.WORD[6].W.B0.CLK_B
+ SLICE[2].RAM8x32.WORD[6].W.B0.we_wire VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[6].W.B0.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[2].RAM8x32.WORD[6].W.B0.CGAND SLICE[2].RAM8x32.WORD[6].W.B0.SEL
+ SLICE[2].RAM8x32.WORD[0].W.B0.WE VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[6].W.B0.we_wire sky130_fd_sc_hd__and2_1
XSLICE[2].RAM8x32.WORD[6].W.B0.CLKINV SLICE[2].RAM8x32.WORD[6].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[6].W.B0.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[6].W.B0.SELINV SLICE[2].RAM8x32.WORD[6].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[6].W.B0.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[6].W.B1.BIT[0].LATCH SLICE[0].RAM8x32.Di[8]
+ SLICE[2].RAM8x32.WORD[6].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[6].W.B1.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[6].W.B1.BIT[0].OBUF
+ SLICE[2].RAM8x32.WORD[6].W.B1.q_wire[0] SLICE[2].RAM8x32.WORD[6].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[8] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[6].W.B1.BIT[1].LATCH SLICE[0].RAM8x32.Di[9]
+ SLICE[2].RAM8x32.WORD[6].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[6].W.B1.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[6].W.B1.BIT[1].OBUF
+ SLICE[2].RAM8x32.WORD[6].W.B1.q_wire[1] SLICE[2].RAM8x32.WORD[6].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[9] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[6].W.B1.BIT[2].LATCH SLICE[0].RAM8x32.Di[10]
+ SLICE[2].RAM8x32.WORD[6].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[6].W.B1.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[6].W.B1.BIT[2].OBUF
+ SLICE[2].RAM8x32.WORD[6].W.B1.q_wire[2] SLICE[2].RAM8x32.WORD[6].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[10] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[6].W.B1.BIT[3].LATCH SLICE[0].RAM8x32.Di[11]
+ SLICE[2].RAM8x32.WORD[6].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[6].W.B1.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[6].W.B1.BIT[3].OBUF
+ SLICE[2].RAM8x32.WORD[6].W.B1.q_wire[3] SLICE[2].RAM8x32.WORD[6].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[11] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[6].W.B1.BIT[4].LATCH SLICE[0].RAM8x32.Di[12]
+ SLICE[2].RAM8x32.WORD[6].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[6].W.B1.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[6].W.B1.BIT[4].OBUF
+ SLICE[2].RAM8x32.WORD[6].W.B1.q_wire[4] SLICE[2].RAM8x32.WORD[6].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[12] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[6].W.B1.BIT[5].LATCH SLICE[0].RAM8x32.Di[13]
+ SLICE[2].RAM8x32.WORD[6].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[6].W.B1.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[6].W.B1.BIT[5].OBUF
+ SLICE[2].RAM8x32.WORD[6].W.B1.q_wire[5] SLICE[2].RAM8x32.WORD[6].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[13] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[6].W.B1.BIT[6].LATCH SLICE[0].RAM8x32.Di[14]
+ SLICE[2].RAM8x32.WORD[6].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[6].W.B1.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[6].W.B1.BIT[6].OBUF
+ SLICE[2].RAM8x32.WORD[6].W.B1.q_wire[6] SLICE[2].RAM8x32.WORD[6].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[14] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[6].W.B1.BIT[7].LATCH SLICE[0].RAM8x32.Di[15]
+ SLICE[2].RAM8x32.WORD[6].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[6].W.B1.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[6].W.B1.BIT[7].OBUF
+ SLICE[2].RAM8x32.WORD[6].W.B1.q_wire[7] SLICE[2].RAM8x32.WORD[6].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[15] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[6].W.B1.CG SLICE[2].RAM8x32.WORD[6].W.B1.CLK_B
+ SLICE[2].RAM8x32.WORD[6].W.B1.we_wire VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[6].W.B1.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[2].RAM8x32.WORD[6].W.B1.CGAND SLICE[2].RAM8x32.WORD[6].W.B0.SEL
+ SLICE[2].RAM8x32.WORD[0].W.B1.WE VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[6].W.B1.we_wire sky130_fd_sc_hd__and2_1
XSLICE[2].RAM8x32.WORD[6].W.B1.CLKINV SLICE[2].RAM8x32.WORD[6].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[6].W.B1.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[6].W.B1.SELINV SLICE[2].RAM8x32.WORD[6].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[6].W.B1.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[6].W.B2.BIT[0].LATCH SLICE[0].RAM8x32.Di[16]
+ SLICE[2].RAM8x32.WORD[6].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[6].W.B2.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[6].W.B2.BIT[0].OBUF
+ SLICE[2].RAM8x32.WORD[6].W.B2.q_wire[0] SLICE[2].RAM8x32.WORD[6].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[16] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[6].W.B2.BIT[1].LATCH SLICE[0].RAM8x32.Di[17]
+ SLICE[2].RAM8x32.WORD[6].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[6].W.B2.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[6].W.B2.BIT[1].OBUF
+ SLICE[2].RAM8x32.WORD[6].W.B2.q_wire[1] SLICE[2].RAM8x32.WORD[6].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[17] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[6].W.B2.BIT[2].LATCH SLICE[0].RAM8x32.Di[18]
+ SLICE[2].RAM8x32.WORD[6].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[6].W.B2.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[6].W.B2.BIT[2].OBUF
+ SLICE[2].RAM8x32.WORD[6].W.B2.q_wire[2] SLICE[2].RAM8x32.WORD[6].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[18] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[6].W.B2.BIT[3].LATCH SLICE[0].RAM8x32.Di[19]
+ SLICE[2].RAM8x32.WORD[6].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[6].W.B2.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[6].W.B2.BIT[3].OBUF
+ SLICE[2].RAM8x32.WORD[6].W.B2.q_wire[3] SLICE[2].RAM8x32.WORD[6].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[19] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[6].W.B2.BIT[4].LATCH SLICE[0].RAM8x32.Di[20]
+ SLICE[2].RAM8x32.WORD[6].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[6].W.B2.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[6].W.B2.BIT[4].OBUF
+ SLICE[2].RAM8x32.WORD[6].W.B2.q_wire[4] SLICE[2].RAM8x32.WORD[6].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[20] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[6].W.B2.BIT[5].LATCH SLICE[0].RAM8x32.Di[21]
+ SLICE[2].RAM8x32.WORD[6].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[6].W.B2.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[6].W.B2.BIT[5].OBUF
+ SLICE[2].RAM8x32.WORD[6].W.B2.q_wire[5] SLICE[2].RAM8x32.WORD[6].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[21] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[6].W.B2.BIT[6].LATCH SLICE[0].RAM8x32.Di[22]
+ SLICE[2].RAM8x32.WORD[6].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[6].W.B2.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[6].W.B2.BIT[6].OBUF
+ SLICE[2].RAM8x32.WORD[6].W.B2.q_wire[6] SLICE[2].RAM8x32.WORD[6].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[22] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[6].W.B2.BIT[7].LATCH SLICE[0].RAM8x32.Di[23]
+ SLICE[2].RAM8x32.WORD[6].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[6].W.B2.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[6].W.B2.BIT[7].OBUF
+ SLICE[2].RAM8x32.WORD[6].W.B2.q_wire[7] SLICE[2].RAM8x32.WORD[6].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[23] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[6].W.B2.CG SLICE[2].RAM8x32.WORD[6].W.B2.CLK_B
+ SLICE[2].RAM8x32.WORD[6].W.B2.we_wire VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[6].W.B2.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[2].RAM8x32.WORD[6].W.B2.CGAND SLICE[2].RAM8x32.WORD[6].W.B0.SEL
+ SLICE[2].RAM8x32.WORD[0].W.B2.WE VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[6].W.B2.we_wire sky130_fd_sc_hd__and2_1
XSLICE[2].RAM8x32.WORD[6].W.B2.CLKINV SLICE[2].RAM8x32.WORD[6].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[6].W.B2.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[6].W.B2.SELINV SLICE[2].RAM8x32.WORD[6].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[6].W.B2.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[6].W.B3.BIT[0].LATCH SLICE[0].RAM8x32.Di[24]
+ SLICE[2].RAM8x32.WORD[6].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[6].W.B3.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[6].W.B3.BIT[0].OBUF
+ SLICE[2].RAM8x32.WORD[6].W.B3.q_wire[0] SLICE[2].RAM8x32.WORD[6].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[24] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[6].W.B3.BIT[1].LATCH SLICE[0].RAM8x32.Di[25]
+ SLICE[2].RAM8x32.WORD[6].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[6].W.B3.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[6].W.B3.BIT[1].OBUF
+ SLICE[2].RAM8x32.WORD[6].W.B3.q_wire[1] SLICE[2].RAM8x32.WORD[6].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[25] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[6].W.B3.BIT[2].LATCH SLICE[0].RAM8x32.Di[26]
+ SLICE[2].RAM8x32.WORD[6].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[6].W.B3.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[6].W.B3.BIT[2].OBUF
+ SLICE[2].RAM8x32.WORD[6].W.B3.q_wire[2] SLICE[2].RAM8x32.WORD[6].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[26] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[6].W.B3.BIT[3].LATCH SLICE[0].RAM8x32.Di[27]
+ SLICE[2].RAM8x32.WORD[6].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[6].W.B3.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[6].W.B3.BIT[3].OBUF
+ SLICE[2].RAM8x32.WORD[6].W.B3.q_wire[3] SLICE[2].RAM8x32.WORD[6].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[27] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[6].W.B3.BIT[4].LATCH SLICE[0].RAM8x32.Di[28]
+ SLICE[2].RAM8x32.WORD[6].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[6].W.B3.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[6].W.B3.BIT[4].OBUF
+ SLICE[2].RAM8x32.WORD[6].W.B3.q_wire[4] SLICE[2].RAM8x32.WORD[6].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[28] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[6].W.B3.BIT[5].LATCH SLICE[0].RAM8x32.Di[29]
+ SLICE[2].RAM8x32.WORD[6].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[6].W.B3.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[6].W.B3.BIT[5].OBUF
+ SLICE[2].RAM8x32.WORD[6].W.B3.q_wire[5] SLICE[2].RAM8x32.WORD[6].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[29] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[6].W.B3.BIT[6].LATCH SLICE[0].RAM8x32.Di[30]
+ SLICE[2].RAM8x32.WORD[6].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[6].W.B3.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[6].W.B3.BIT[6].OBUF
+ SLICE[2].RAM8x32.WORD[6].W.B3.q_wire[6] SLICE[2].RAM8x32.WORD[6].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[30] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[6].W.B3.BIT[7].LATCH SLICE[0].RAM8x32.Di[31]
+ SLICE[2].RAM8x32.WORD[6].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[6].W.B3.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[6].W.B3.BIT[7].OBUF
+ SLICE[2].RAM8x32.WORD[6].W.B3.q_wire[7] SLICE[2].RAM8x32.WORD[6].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[31] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[6].W.B3.CG SLICE[2].RAM8x32.WORD[6].W.B3.CLK_B
+ SLICE[2].RAM8x32.WORD[6].W.B3.we_wire VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[6].W.B3.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[2].RAM8x32.WORD[6].W.B3.CGAND SLICE[2].RAM8x32.WORD[6].W.B0.SEL
+ SLICE[2].RAM8x32.WORD[0].W.B3.WE VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[6].W.B3.we_wire sky130_fd_sc_hd__and2_1
XSLICE[2].RAM8x32.WORD[6].W.B3.CLKINV SLICE[2].RAM8x32.WORD[6].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[6].W.B3.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[6].W.B3.SELINV SLICE[2].RAM8x32.WORD[6].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[6].W.B3.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[6].W.CLKBUF SLICE[2].RAM8x32.CLK_buf VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[6].W.B0.CLK sky130_fd_sc_hd__clkbuf_1
XSLICE[2].RAM8x32.WORD[6].W.SELBUF SLICE[2].RAM8x32.WORD[6].W.SEL VGND VGND
+ VPWR VPWR SLICE[2].RAM8x32.WORD[6].W.B0.SEL sky130_fd_sc_hd__clkbuf_2
XSLICE[2].RAM8x32.WORD[7].W.B0.BIT[0].LATCH SLICE[0].RAM8x32.Di[0]
+ SLICE[2].RAM8x32.WORD[7].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[7].W.B0.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[7].W.B0.BIT[0].OBUF
+ SLICE[2].RAM8x32.WORD[7].W.B0.q_wire[0] SLICE[2].RAM8x32.WORD[7].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[0] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[7].W.B0.BIT[1].LATCH SLICE[0].RAM8x32.Di[1]
+ SLICE[2].RAM8x32.WORD[7].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[7].W.B0.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[7].W.B0.BIT[1].OBUF
+ SLICE[2].RAM8x32.WORD[7].W.B0.q_wire[1] SLICE[2].RAM8x32.WORD[7].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[1] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[7].W.B0.BIT[2].LATCH SLICE[0].RAM8x32.Di[2]
+ SLICE[2].RAM8x32.WORD[7].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[7].W.B0.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[7].W.B0.BIT[2].OBUF
+ SLICE[2].RAM8x32.WORD[7].W.B0.q_wire[2] SLICE[2].RAM8x32.WORD[7].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[2] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[7].W.B0.BIT[3].LATCH SLICE[0].RAM8x32.Di[3]
+ SLICE[2].RAM8x32.WORD[7].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[7].W.B0.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[7].W.B0.BIT[3].OBUF
+ SLICE[2].RAM8x32.WORD[7].W.B0.q_wire[3] SLICE[2].RAM8x32.WORD[7].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[3] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[7].W.B0.BIT[4].LATCH SLICE[0].RAM8x32.Di[4]
+ SLICE[2].RAM8x32.WORD[7].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[7].W.B0.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[7].W.B0.BIT[4].OBUF
+ SLICE[2].RAM8x32.WORD[7].W.B0.q_wire[4] SLICE[2].RAM8x32.WORD[7].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[4] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[7].W.B0.BIT[5].LATCH SLICE[0].RAM8x32.Di[5]
+ SLICE[2].RAM8x32.WORD[7].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[7].W.B0.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[7].W.B0.BIT[5].OBUF
+ SLICE[2].RAM8x32.WORD[7].W.B0.q_wire[5] SLICE[2].RAM8x32.WORD[7].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[5] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[7].W.B0.BIT[6].LATCH SLICE[0].RAM8x32.Di[6]
+ SLICE[2].RAM8x32.WORD[7].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[7].W.B0.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[7].W.B0.BIT[6].OBUF
+ SLICE[2].RAM8x32.WORD[7].W.B0.q_wire[6] SLICE[2].RAM8x32.WORD[7].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[6] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[7].W.B0.BIT[7].LATCH SLICE[0].RAM8x32.Di[7]
+ SLICE[2].RAM8x32.WORD[7].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[7].W.B0.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[7].W.B0.BIT[7].OBUF
+ SLICE[2].RAM8x32.WORD[7].W.B0.q_wire[7] SLICE[2].RAM8x32.WORD[7].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[7] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[7].W.B0.CG SLICE[2].RAM8x32.WORD[7].W.B0.CLK_B
+ SLICE[2].RAM8x32.WORD[7].W.B0.we_wire VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[7].W.B0.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[2].RAM8x32.WORD[7].W.B0.CGAND SLICE[2].RAM8x32.WORD[7].W.B0.SEL
+ SLICE[2].RAM8x32.WORD[0].W.B0.WE VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[7].W.B0.we_wire sky130_fd_sc_hd__and2_1
XSLICE[2].RAM8x32.WORD[7].W.B0.CLKINV SLICE[2].RAM8x32.WORD[7].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[7].W.B0.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[7].W.B0.SELINV SLICE[2].RAM8x32.WORD[7].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[7].W.B0.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[7].W.B1.BIT[0].LATCH SLICE[0].RAM8x32.Di[8]
+ SLICE[2].RAM8x32.WORD[7].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[7].W.B1.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[7].W.B1.BIT[0].OBUF
+ SLICE[2].RAM8x32.WORD[7].W.B1.q_wire[0] SLICE[2].RAM8x32.WORD[7].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[8] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[7].W.B1.BIT[1].LATCH SLICE[0].RAM8x32.Di[9]
+ SLICE[2].RAM8x32.WORD[7].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[7].W.B1.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[7].W.B1.BIT[1].OBUF
+ SLICE[2].RAM8x32.WORD[7].W.B1.q_wire[1] SLICE[2].RAM8x32.WORD[7].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[9] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[7].W.B1.BIT[2].LATCH SLICE[0].RAM8x32.Di[10]
+ SLICE[2].RAM8x32.WORD[7].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[7].W.B1.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[7].W.B1.BIT[2].OBUF
+ SLICE[2].RAM8x32.WORD[7].W.B1.q_wire[2] SLICE[2].RAM8x32.WORD[7].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[10] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[7].W.B1.BIT[3].LATCH SLICE[0].RAM8x32.Di[11]
+ SLICE[2].RAM8x32.WORD[7].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[7].W.B1.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[7].W.B1.BIT[3].OBUF
+ SLICE[2].RAM8x32.WORD[7].W.B1.q_wire[3] SLICE[2].RAM8x32.WORD[7].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[11] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[7].W.B1.BIT[4].LATCH SLICE[0].RAM8x32.Di[12]
+ SLICE[2].RAM8x32.WORD[7].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[7].W.B1.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[7].W.B1.BIT[4].OBUF
+ SLICE[2].RAM8x32.WORD[7].W.B1.q_wire[4] SLICE[2].RAM8x32.WORD[7].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[12] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[7].W.B1.BIT[5].LATCH SLICE[0].RAM8x32.Di[13]
+ SLICE[2].RAM8x32.WORD[7].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[7].W.B1.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[7].W.B1.BIT[5].OBUF
+ SLICE[2].RAM8x32.WORD[7].W.B1.q_wire[5] SLICE[2].RAM8x32.WORD[7].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[13] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[7].W.B1.BIT[6].LATCH SLICE[0].RAM8x32.Di[14]
+ SLICE[2].RAM8x32.WORD[7].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[7].W.B1.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[7].W.B1.BIT[6].OBUF
+ SLICE[2].RAM8x32.WORD[7].W.B1.q_wire[6] SLICE[2].RAM8x32.WORD[7].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[14] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[7].W.B1.BIT[7].LATCH SLICE[0].RAM8x32.Di[15]
+ SLICE[2].RAM8x32.WORD[7].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[7].W.B1.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[7].W.B1.BIT[7].OBUF
+ SLICE[2].RAM8x32.WORD[7].W.B1.q_wire[7] SLICE[2].RAM8x32.WORD[7].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[15] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[7].W.B1.CG SLICE[2].RAM8x32.WORD[7].W.B1.CLK_B
+ SLICE[2].RAM8x32.WORD[7].W.B1.we_wire VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[7].W.B1.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[2].RAM8x32.WORD[7].W.B1.CGAND SLICE[2].RAM8x32.WORD[7].W.B0.SEL
+ SLICE[2].RAM8x32.WORD[0].W.B1.WE VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[7].W.B1.we_wire sky130_fd_sc_hd__and2_1
XSLICE[2].RAM8x32.WORD[7].W.B1.CLKINV SLICE[2].RAM8x32.WORD[7].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[7].W.B1.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[7].W.B1.SELINV SLICE[2].RAM8x32.WORD[7].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[7].W.B1.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[7].W.B2.BIT[0].LATCH SLICE[0].RAM8x32.Di[16]
+ SLICE[2].RAM8x32.WORD[7].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[7].W.B2.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[7].W.B2.BIT[0].OBUF
+ SLICE[2].RAM8x32.WORD[7].W.B2.q_wire[0] SLICE[2].RAM8x32.WORD[7].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[16] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[7].W.B2.BIT[1].LATCH SLICE[0].RAM8x32.Di[17]
+ SLICE[2].RAM8x32.WORD[7].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[7].W.B2.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[7].W.B2.BIT[1].OBUF
+ SLICE[2].RAM8x32.WORD[7].W.B2.q_wire[1] SLICE[2].RAM8x32.WORD[7].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[17] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[7].W.B2.BIT[2].LATCH SLICE[0].RAM8x32.Di[18]
+ SLICE[2].RAM8x32.WORD[7].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[7].W.B2.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[7].W.B2.BIT[2].OBUF
+ SLICE[2].RAM8x32.WORD[7].W.B2.q_wire[2] SLICE[2].RAM8x32.WORD[7].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[18] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[7].W.B2.BIT[3].LATCH SLICE[0].RAM8x32.Di[19]
+ SLICE[2].RAM8x32.WORD[7].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[7].W.B2.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[7].W.B2.BIT[3].OBUF
+ SLICE[2].RAM8x32.WORD[7].W.B2.q_wire[3] SLICE[2].RAM8x32.WORD[7].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[19] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[7].W.B2.BIT[4].LATCH SLICE[0].RAM8x32.Di[20]
+ SLICE[2].RAM8x32.WORD[7].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[7].W.B2.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[7].W.B2.BIT[4].OBUF
+ SLICE[2].RAM8x32.WORD[7].W.B2.q_wire[4] SLICE[2].RAM8x32.WORD[7].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[20] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[7].W.B2.BIT[5].LATCH SLICE[0].RAM8x32.Di[21]
+ SLICE[2].RAM8x32.WORD[7].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[7].W.B2.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[7].W.B2.BIT[5].OBUF
+ SLICE[2].RAM8x32.WORD[7].W.B2.q_wire[5] SLICE[2].RAM8x32.WORD[7].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[21] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[7].W.B2.BIT[6].LATCH SLICE[0].RAM8x32.Di[22]
+ SLICE[2].RAM8x32.WORD[7].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[7].W.B2.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[7].W.B2.BIT[6].OBUF
+ SLICE[2].RAM8x32.WORD[7].W.B2.q_wire[6] SLICE[2].RAM8x32.WORD[7].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[22] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[7].W.B2.BIT[7].LATCH SLICE[0].RAM8x32.Di[23]
+ SLICE[2].RAM8x32.WORD[7].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[7].W.B2.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[7].W.B2.BIT[7].OBUF
+ SLICE[2].RAM8x32.WORD[7].W.B2.q_wire[7] SLICE[2].RAM8x32.WORD[7].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[23] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[7].W.B2.CG SLICE[2].RAM8x32.WORD[7].W.B2.CLK_B
+ SLICE[2].RAM8x32.WORD[7].W.B2.we_wire VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[7].W.B2.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[2].RAM8x32.WORD[7].W.B2.CGAND SLICE[2].RAM8x32.WORD[7].W.B0.SEL
+ SLICE[2].RAM8x32.WORD[0].W.B2.WE VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[7].W.B2.we_wire sky130_fd_sc_hd__and2_1
XSLICE[2].RAM8x32.WORD[7].W.B2.CLKINV SLICE[2].RAM8x32.WORD[7].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[7].W.B2.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[7].W.B2.SELINV SLICE[2].RAM8x32.WORD[7].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[7].W.B2.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[7].W.B3.BIT[0].LATCH SLICE[0].RAM8x32.Di[24]
+ SLICE[2].RAM8x32.WORD[7].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[7].W.B3.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[7].W.B3.BIT[0].OBUF
+ SLICE[2].RAM8x32.WORD[7].W.B3.q_wire[0] SLICE[2].RAM8x32.WORD[7].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[24] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[7].W.B3.BIT[1].LATCH SLICE[0].RAM8x32.Di[25]
+ SLICE[2].RAM8x32.WORD[7].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[7].W.B3.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[7].W.B3.BIT[1].OBUF
+ SLICE[2].RAM8x32.WORD[7].W.B3.q_wire[1] SLICE[2].RAM8x32.WORD[7].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[25] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[7].W.B3.BIT[2].LATCH SLICE[0].RAM8x32.Di[26]
+ SLICE[2].RAM8x32.WORD[7].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[7].W.B3.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[7].W.B3.BIT[2].OBUF
+ SLICE[2].RAM8x32.WORD[7].W.B3.q_wire[2] SLICE[2].RAM8x32.WORD[7].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[26] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[7].W.B3.BIT[3].LATCH SLICE[0].RAM8x32.Di[27]
+ SLICE[2].RAM8x32.WORD[7].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[7].W.B3.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[7].W.B3.BIT[3].OBUF
+ SLICE[2].RAM8x32.WORD[7].W.B3.q_wire[3] SLICE[2].RAM8x32.WORD[7].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[27] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[7].W.B3.BIT[4].LATCH SLICE[0].RAM8x32.Di[28]
+ SLICE[2].RAM8x32.WORD[7].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[7].W.B3.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[7].W.B3.BIT[4].OBUF
+ SLICE[2].RAM8x32.WORD[7].W.B3.q_wire[4] SLICE[2].RAM8x32.WORD[7].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[28] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[7].W.B3.BIT[5].LATCH SLICE[0].RAM8x32.Di[29]
+ SLICE[2].RAM8x32.WORD[7].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[7].W.B3.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[7].W.B3.BIT[5].OBUF
+ SLICE[2].RAM8x32.WORD[7].W.B3.q_wire[5] SLICE[2].RAM8x32.WORD[7].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[29] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[7].W.B3.BIT[6].LATCH SLICE[0].RAM8x32.Di[30]
+ SLICE[2].RAM8x32.WORD[7].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[7].W.B3.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[7].W.B3.BIT[6].OBUF
+ SLICE[2].RAM8x32.WORD[7].W.B3.q_wire[6] SLICE[2].RAM8x32.WORD[7].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[30] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[7].W.B3.BIT[7].LATCH SLICE[0].RAM8x32.Di[31]
+ SLICE[2].RAM8x32.WORD[7].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[7].W.B3.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[2].RAM8x32.WORD[7].W.B3.BIT[7].OBUF
+ SLICE[2].RAM8x32.WORD[7].W.B3.q_wire[7] SLICE[2].RAM8x32.WORD[7].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[31] sky130_fd_sc_hd__ebufn_2
XSLICE[2].RAM8x32.WORD[7].W.B3.CG SLICE[2].RAM8x32.WORD[7].W.B3.CLK_B
+ SLICE[2].RAM8x32.WORD[7].W.B3.we_wire VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[7].W.B3.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[2].RAM8x32.WORD[7].W.B3.CGAND SLICE[2].RAM8x32.WORD[7].W.B0.SEL
+ SLICE[2].RAM8x32.WORD[0].W.B3.WE VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[7].W.B3.we_wire sky130_fd_sc_hd__and2_1
XSLICE[2].RAM8x32.WORD[7].W.B3.CLKINV SLICE[2].RAM8x32.WORD[7].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[7].W.B3.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[7].W.B3.SELINV SLICE[2].RAM8x32.WORD[7].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[2].RAM8x32.WORD[7].W.B3.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[2].RAM8x32.WORD[7].W.CLKBUF SLICE[2].RAM8x32.CLK_buf VGND VGND VPWR VPWR
+ SLICE[2].RAM8x32.WORD[7].W.B0.CLK sky130_fd_sc_hd__clkbuf_1
XSLICE[2].RAM8x32.WORD[7].W.SELBUF SLICE[2].RAM8x32.WORD[7].W.SEL VGND VGND
+ VPWR VPWR SLICE[2].RAM8x32.WORD[7].W.B0.SEL sky130_fd_sc_hd__clkbuf_2
XSLICE[3].RAM8x32.CLKBUF SLICE[0].RAM8x32.CLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.CLK_buf sky130_fd_sc_hd__clkbuf_2
XSLICE[3].RAM8x32.DEC.ABUF[0] SLICE[0].RAM8x32.A[0] VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.DEC.A_buf[0] sky130_fd_sc_hd__clkbuf_2
XSLICE[3].RAM8x32.DEC.ABUF[1] SLICE[0].RAM8x32.A[1] VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.DEC.A_buf[1] sky130_fd_sc_hd__clkbuf_2
XSLICE[3].RAM8x32.DEC.ABUF[2] SLICE[0].RAM8x32.A[2] VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.DEC.A_buf[2] sky130_fd_sc_hd__clkbuf_2
XSLICE[3].RAM8x32.DEC.AND0 SLICE[3].RAM8x32.DEC.A_buf[0]
+ SLICE[3].RAM8x32.DEC.A_buf[1] SLICE[3].RAM8x32.DEC.A_buf[2]
+ SLICE[3].RAM8x32.DEC.EN_buf VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[0].W.SEL sky130_fd_sc_hd__nor4b_2
XSLICE[3].RAM8x32.DEC.AND1 SLICE[3].RAM8x32.DEC.A_buf[2]
+ SLICE[3].RAM8x32.DEC.A_buf[1] SLICE[3].RAM8x32.DEC.A_buf[0]
+ SLICE[3].RAM8x32.DEC.EN_buf VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[1].W.SEL sky130_fd_sc_hd__and4bb_2
XSLICE[3].RAM8x32.DEC.AND2 SLICE[3].RAM8x32.DEC.A_buf[2]
+ SLICE[3].RAM8x32.DEC.A_buf[0] SLICE[3].RAM8x32.DEC.A_buf[1]
+ SLICE[3].RAM8x32.DEC.EN_buf VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[2].W.SEL sky130_fd_sc_hd__and4bb_2
XSLICE[3].RAM8x32.DEC.AND3 SLICE[3].RAM8x32.DEC.A_buf[2]
+ SLICE[3].RAM8x32.DEC.A_buf[1] SLICE[3].RAM8x32.DEC.A_buf[0]
+ SLICE[3].RAM8x32.DEC.EN_buf VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[3].W.SEL sky130_fd_sc_hd__and4b_2
XSLICE[3].RAM8x32.DEC.AND4 SLICE[3].RAM8x32.DEC.A_buf[0]
+ SLICE[3].RAM8x32.DEC.A_buf[1] SLICE[3].RAM8x32.DEC.A_buf[2]
+ SLICE[3].RAM8x32.DEC.EN_buf VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[4].W.SEL sky130_fd_sc_hd__and4bb_2
XSLICE[3].RAM8x32.DEC.AND5 SLICE[3].RAM8x32.DEC.A_buf[1]
+ SLICE[3].RAM8x32.DEC.A_buf[0] SLICE[3].RAM8x32.DEC.A_buf[2]
+ SLICE[3].RAM8x32.DEC.EN_buf VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[5].W.SEL sky130_fd_sc_hd__and4b_2
XSLICE[3].RAM8x32.DEC.AND6 SLICE[3].RAM8x32.DEC.A_buf[0]
+ SLICE[3].RAM8x32.DEC.A_buf[1] SLICE[3].RAM8x32.DEC.A_buf[2]
+ SLICE[3].RAM8x32.DEC.EN_buf VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[6].W.SEL sky130_fd_sc_hd__and4b_2
XSLICE[3].RAM8x32.DEC.AND7 SLICE[3].RAM8x32.DEC.A_buf[0]
+ SLICE[3].RAM8x32.DEC.A_buf[1] SLICE[3].RAM8x32.DEC.A_buf[2]
+ SLICE[3].RAM8x32.DEC.EN_buf VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[7].W.SEL sky130_fd_sc_hd__and4_2
XSLICE[3].RAM8x32.DEC.ENBUF SLICE[3].RAM8x32.DEC.EN VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.DEC.EN_buf sky130_fd_sc_hd__clkbuf_2
XSLICE[3].RAM8x32.WEBUF[0] SLICE[0].RAM8x32.WE[0] VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[0].W.B0.WE sky130_fd_sc_hd__clkbuf_2
XSLICE[3].RAM8x32.WEBUF[1] SLICE[0].RAM8x32.WE[1] VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[0].W.B1.WE sky130_fd_sc_hd__clkbuf_2
XSLICE[3].RAM8x32.WEBUF[2] SLICE[0].RAM8x32.WE[2] VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[0].W.B2.WE sky130_fd_sc_hd__clkbuf_2
XSLICE[3].RAM8x32.WEBUF[3] SLICE[0].RAM8x32.WE[3] VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[0].W.B3.WE sky130_fd_sc_hd__clkbuf_2
XSLICE[3].RAM8x32.WORD[0].W.B0.BIT[0].LATCH SLICE[0].RAM8x32.Di[0]
+ SLICE[3].RAM8x32.WORD[0].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[0].W.B0.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[0].W.B0.BIT[0].OBUF
+ SLICE[3].RAM8x32.WORD[0].W.B0.q_wire[0] SLICE[3].RAM8x32.WORD[0].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[0] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[0].W.B0.BIT[1].LATCH SLICE[0].RAM8x32.Di[1]
+ SLICE[3].RAM8x32.WORD[0].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[0].W.B0.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[0].W.B0.BIT[1].OBUF
+ SLICE[3].RAM8x32.WORD[0].W.B0.q_wire[1] SLICE[3].RAM8x32.WORD[0].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[1] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[0].W.B0.BIT[2].LATCH SLICE[0].RAM8x32.Di[2]
+ SLICE[3].RAM8x32.WORD[0].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[0].W.B0.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[0].W.B0.BIT[2].OBUF
+ SLICE[3].RAM8x32.WORD[0].W.B0.q_wire[2] SLICE[3].RAM8x32.WORD[0].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[2] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[0].W.B0.BIT[3].LATCH SLICE[0].RAM8x32.Di[3]
+ SLICE[3].RAM8x32.WORD[0].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[0].W.B0.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[0].W.B0.BIT[3].OBUF
+ SLICE[3].RAM8x32.WORD[0].W.B0.q_wire[3] SLICE[3].RAM8x32.WORD[0].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[3] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[0].W.B0.BIT[4].LATCH SLICE[0].RAM8x32.Di[4]
+ SLICE[3].RAM8x32.WORD[0].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[0].W.B0.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[0].W.B0.BIT[4].OBUF
+ SLICE[3].RAM8x32.WORD[0].W.B0.q_wire[4] SLICE[3].RAM8x32.WORD[0].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[4] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[0].W.B0.BIT[5].LATCH SLICE[0].RAM8x32.Di[5]
+ SLICE[3].RAM8x32.WORD[0].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[0].W.B0.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[0].W.B0.BIT[5].OBUF
+ SLICE[3].RAM8x32.WORD[0].W.B0.q_wire[5] SLICE[3].RAM8x32.WORD[0].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[5] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[0].W.B0.BIT[6].LATCH SLICE[0].RAM8x32.Di[6]
+ SLICE[3].RAM8x32.WORD[0].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[0].W.B0.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[0].W.B0.BIT[6].OBUF
+ SLICE[3].RAM8x32.WORD[0].W.B0.q_wire[6] SLICE[3].RAM8x32.WORD[0].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[6] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[0].W.B0.BIT[7].LATCH SLICE[0].RAM8x32.Di[7]
+ SLICE[3].RAM8x32.WORD[0].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[0].W.B0.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[0].W.B0.BIT[7].OBUF
+ SLICE[3].RAM8x32.WORD[0].W.B0.q_wire[7] SLICE[3].RAM8x32.WORD[0].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[7] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[0].W.B0.CG SLICE[3].RAM8x32.WORD[0].W.B0.CLK_B
+ SLICE[3].RAM8x32.WORD[0].W.B0.we_wire VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[0].W.B0.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[3].RAM8x32.WORD[0].W.B0.CGAND SLICE[3].RAM8x32.WORD[0].W.B0.SEL
+ SLICE[3].RAM8x32.WORD[0].W.B0.WE VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[0].W.B0.we_wire sky130_fd_sc_hd__and2_1
XSLICE[3].RAM8x32.WORD[0].W.B0.CLKINV SLICE[3].RAM8x32.WORD[0].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[0].W.B0.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[0].W.B0.SELINV SLICE[3].RAM8x32.WORD[0].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[0].W.B0.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[0].W.B1.BIT[0].LATCH SLICE[0].RAM8x32.Di[8]
+ SLICE[3].RAM8x32.WORD[0].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[0].W.B1.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[0].W.B1.BIT[0].OBUF
+ SLICE[3].RAM8x32.WORD[0].W.B1.q_wire[0] SLICE[3].RAM8x32.WORD[0].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[8] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[0].W.B1.BIT[1].LATCH SLICE[0].RAM8x32.Di[9]
+ SLICE[3].RAM8x32.WORD[0].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[0].W.B1.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[0].W.B1.BIT[1].OBUF
+ SLICE[3].RAM8x32.WORD[0].W.B1.q_wire[1] SLICE[3].RAM8x32.WORD[0].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[9] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[0].W.B1.BIT[2].LATCH SLICE[0].RAM8x32.Di[10]
+ SLICE[3].RAM8x32.WORD[0].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[0].W.B1.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[0].W.B1.BIT[2].OBUF
+ SLICE[3].RAM8x32.WORD[0].W.B1.q_wire[2] SLICE[3].RAM8x32.WORD[0].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[10] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[0].W.B1.BIT[3].LATCH SLICE[0].RAM8x32.Di[11]
+ SLICE[3].RAM8x32.WORD[0].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[0].W.B1.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[0].W.B1.BIT[3].OBUF
+ SLICE[3].RAM8x32.WORD[0].W.B1.q_wire[3] SLICE[3].RAM8x32.WORD[0].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[11] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[0].W.B1.BIT[4].LATCH SLICE[0].RAM8x32.Di[12]
+ SLICE[3].RAM8x32.WORD[0].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[0].W.B1.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[0].W.B1.BIT[4].OBUF
+ SLICE[3].RAM8x32.WORD[0].W.B1.q_wire[4] SLICE[3].RAM8x32.WORD[0].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[12] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[0].W.B1.BIT[5].LATCH SLICE[0].RAM8x32.Di[13]
+ SLICE[3].RAM8x32.WORD[0].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[0].W.B1.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[0].W.B1.BIT[5].OBUF
+ SLICE[3].RAM8x32.WORD[0].W.B1.q_wire[5] SLICE[3].RAM8x32.WORD[0].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[13] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[0].W.B1.BIT[6].LATCH SLICE[0].RAM8x32.Di[14]
+ SLICE[3].RAM8x32.WORD[0].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[0].W.B1.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[0].W.B1.BIT[6].OBUF
+ SLICE[3].RAM8x32.WORD[0].W.B1.q_wire[6] SLICE[3].RAM8x32.WORD[0].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[14] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[0].W.B1.BIT[7].LATCH SLICE[0].RAM8x32.Di[15]
+ SLICE[3].RAM8x32.WORD[0].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[0].W.B1.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[0].W.B1.BIT[7].OBUF
+ SLICE[3].RAM8x32.WORD[0].W.B1.q_wire[7] SLICE[3].RAM8x32.WORD[0].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[15] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[0].W.B1.CG SLICE[3].RAM8x32.WORD[0].W.B1.CLK_B
+ SLICE[3].RAM8x32.WORD[0].W.B1.we_wire VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[0].W.B1.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[3].RAM8x32.WORD[0].W.B1.CGAND SLICE[3].RAM8x32.WORD[0].W.B0.SEL
+ SLICE[3].RAM8x32.WORD[0].W.B1.WE VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[0].W.B1.we_wire sky130_fd_sc_hd__and2_1
XSLICE[3].RAM8x32.WORD[0].W.B1.CLKINV SLICE[3].RAM8x32.WORD[0].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[0].W.B1.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[0].W.B1.SELINV SLICE[3].RAM8x32.WORD[0].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[0].W.B1.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[0].W.B2.BIT[0].LATCH SLICE[0].RAM8x32.Di[16]
+ SLICE[3].RAM8x32.WORD[0].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[0].W.B2.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[0].W.B2.BIT[0].OBUF
+ SLICE[3].RAM8x32.WORD[0].W.B2.q_wire[0] SLICE[3].RAM8x32.WORD[0].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[16] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[0].W.B2.BIT[1].LATCH SLICE[0].RAM8x32.Di[17]
+ SLICE[3].RAM8x32.WORD[0].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[0].W.B2.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[0].W.B2.BIT[1].OBUF
+ SLICE[3].RAM8x32.WORD[0].W.B2.q_wire[1] SLICE[3].RAM8x32.WORD[0].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[17] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[0].W.B2.BIT[2].LATCH SLICE[0].RAM8x32.Di[18]
+ SLICE[3].RAM8x32.WORD[0].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[0].W.B2.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[0].W.B2.BIT[2].OBUF
+ SLICE[3].RAM8x32.WORD[0].W.B2.q_wire[2] SLICE[3].RAM8x32.WORD[0].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[18] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[0].W.B2.BIT[3].LATCH SLICE[0].RAM8x32.Di[19]
+ SLICE[3].RAM8x32.WORD[0].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[0].W.B2.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[0].W.B2.BIT[3].OBUF
+ SLICE[3].RAM8x32.WORD[0].W.B2.q_wire[3] SLICE[3].RAM8x32.WORD[0].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[19] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[0].W.B2.BIT[4].LATCH SLICE[0].RAM8x32.Di[20]
+ SLICE[3].RAM8x32.WORD[0].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[0].W.B2.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[0].W.B2.BIT[4].OBUF
+ SLICE[3].RAM8x32.WORD[0].W.B2.q_wire[4] SLICE[3].RAM8x32.WORD[0].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[20] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[0].W.B2.BIT[5].LATCH SLICE[0].RAM8x32.Di[21]
+ SLICE[3].RAM8x32.WORD[0].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[0].W.B2.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[0].W.B2.BIT[5].OBUF
+ SLICE[3].RAM8x32.WORD[0].W.B2.q_wire[5] SLICE[3].RAM8x32.WORD[0].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[21] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[0].W.B2.BIT[6].LATCH SLICE[0].RAM8x32.Di[22]
+ SLICE[3].RAM8x32.WORD[0].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[0].W.B2.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[0].W.B2.BIT[6].OBUF
+ SLICE[3].RAM8x32.WORD[0].W.B2.q_wire[6] SLICE[3].RAM8x32.WORD[0].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[22] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[0].W.B2.BIT[7].LATCH SLICE[0].RAM8x32.Di[23]
+ SLICE[3].RAM8x32.WORD[0].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[0].W.B2.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[0].W.B2.BIT[7].OBUF
+ SLICE[3].RAM8x32.WORD[0].W.B2.q_wire[7] SLICE[3].RAM8x32.WORD[0].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[23] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[0].W.B2.CG SLICE[3].RAM8x32.WORD[0].W.B2.CLK_B
+ SLICE[3].RAM8x32.WORD[0].W.B2.we_wire VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[0].W.B2.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[3].RAM8x32.WORD[0].W.B2.CGAND SLICE[3].RAM8x32.WORD[0].W.B0.SEL
+ SLICE[3].RAM8x32.WORD[0].W.B2.WE VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[0].W.B2.we_wire sky130_fd_sc_hd__and2_1
XSLICE[3].RAM8x32.WORD[0].W.B2.CLKINV SLICE[3].RAM8x32.WORD[0].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[0].W.B2.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[0].W.B2.SELINV SLICE[3].RAM8x32.WORD[0].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[0].W.B2.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[0].W.B3.BIT[0].LATCH SLICE[0].RAM8x32.Di[24]
+ SLICE[3].RAM8x32.WORD[0].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[0].W.B3.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[0].W.B3.BIT[0].OBUF
+ SLICE[3].RAM8x32.WORD[0].W.B3.q_wire[0] SLICE[3].RAM8x32.WORD[0].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[24] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[0].W.B3.BIT[1].LATCH SLICE[0].RAM8x32.Di[25]
+ SLICE[3].RAM8x32.WORD[0].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[0].W.B3.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[0].W.B3.BIT[1].OBUF
+ SLICE[3].RAM8x32.WORD[0].W.B3.q_wire[1] SLICE[3].RAM8x32.WORD[0].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[25] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[0].W.B3.BIT[2].LATCH SLICE[0].RAM8x32.Di[26]
+ SLICE[3].RAM8x32.WORD[0].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[0].W.B3.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[0].W.B3.BIT[2].OBUF
+ SLICE[3].RAM8x32.WORD[0].W.B3.q_wire[2] SLICE[3].RAM8x32.WORD[0].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[26] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[0].W.B3.BIT[3].LATCH SLICE[0].RAM8x32.Di[27]
+ SLICE[3].RAM8x32.WORD[0].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[0].W.B3.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[0].W.B3.BIT[3].OBUF
+ SLICE[3].RAM8x32.WORD[0].W.B3.q_wire[3] SLICE[3].RAM8x32.WORD[0].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[27] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[0].W.B3.BIT[4].LATCH SLICE[0].RAM8x32.Di[28]
+ SLICE[3].RAM8x32.WORD[0].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[0].W.B3.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[0].W.B3.BIT[4].OBUF
+ SLICE[3].RAM8x32.WORD[0].W.B3.q_wire[4] SLICE[3].RAM8x32.WORD[0].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[28] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[0].W.B3.BIT[5].LATCH SLICE[0].RAM8x32.Di[29]
+ SLICE[3].RAM8x32.WORD[0].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[0].W.B3.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[0].W.B3.BIT[5].OBUF
+ SLICE[3].RAM8x32.WORD[0].W.B3.q_wire[5] SLICE[3].RAM8x32.WORD[0].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[29] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[0].W.B3.BIT[6].LATCH SLICE[0].RAM8x32.Di[30]
+ SLICE[3].RAM8x32.WORD[0].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[0].W.B3.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[0].W.B3.BIT[6].OBUF
+ SLICE[3].RAM8x32.WORD[0].W.B3.q_wire[6] SLICE[3].RAM8x32.WORD[0].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[30] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[0].W.B3.BIT[7].LATCH SLICE[0].RAM8x32.Di[31]
+ SLICE[3].RAM8x32.WORD[0].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[0].W.B3.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[0].W.B3.BIT[7].OBUF
+ SLICE[3].RAM8x32.WORD[0].W.B3.q_wire[7] SLICE[3].RAM8x32.WORD[0].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[31] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[0].W.B3.CG SLICE[3].RAM8x32.WORD[0].W.B3.CLK_B
+ SLICE[3].RAM8x32.WORD[0].W.B3.we_wire VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[0].W.B3.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[3].RAM8x32.WORD[0].W.B3.CGAND SLICE[3].RAM8x32.WORD[0].W.B0.SEL
+ SLICE[3].RAM8x32.WORD[0].W.B3.WE VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[0].W.B3.we_wire sky130_fd_sc_hd__and2_1
XSLICE[3].RAM8x32.WORD[0].W.B3.CLKINV SLICE[3].RAM8x32.WORD[0].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[0].W.B3.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[0].W.B3.SELINV SLICE[3].RAM8x32.WORD[0].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[0].W.B3.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[0].W.CLKBUF SLICE[3].RAM8x32.CLK_buf VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[0].W.B0.CLK sky130_fd_sc_hd__clkbuf_1
XSLICE[3].RAM8x32.WORD[0].W.SELBUF SLICE[3].RAM8x32.WORD[0].W.SEL VGND VGND
+ VPWR VPWR SLICE[3].RAM8x32.WORD[0].W.B0.SEL sky130_fd_sc_hd__clkbuf_2
XSLICE[3].RAM8x32.WORD[1].W.B0.BIT[0].LATCH SLICE[0].RAM8x32.Di[0]
+ SLICE[3].RAM8x32.WORD[1].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[1].W.B0.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[1].W.B0.BIT[0].OBUF
+ SLICE[3].RAM8x32.WORD[1].W.B0.q_wire[0] SLICE[3].RAM8x32.WORD[1].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[0] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[1].W.B0.BIT[1].LATCH SLICE[0].RAM8x32.Di[1]
+ SLICE[3].RAM8x32.WORD[1].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[1].W.B0.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[1].W.B0.BIT[1].OBUF
+ SLICE[3].RAM8x32.WORD[1].W.B0.q_wire[1] SLICE[3].RAM8x32.WORD[1].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[1] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[1].W.B0.BIT[2].LATCH SLICE[0].RAM8x32.Di[2]
+ SLICE[3].RAM8x32.WORD[1].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[1].W.B0.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[1].W.B0.BIT[2].OBUF
+ SLICE[3].RAM8x32.WORD[1].W.B0.q_wire[2] SLICE[3].RAM8x32.WORD[1].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[2] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[1].W.B0.BIT[3].LATCH SLICE[0].RAM8x32.Di[3]
+ SLICE[3].RAM8x32.WORD[1].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[1].W.B0.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[1].W.B0.BIT[3].OBUF
+ SLICE[3].RAM8x32.WORD[1].W.B0.q_wire[3] SLICE[3].RAM8x32.WORD[1].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[3] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[1].W.B0.BIT[4].LATCH SLICE[0].RAM8x32.Di[4]
+ SLICE[3].RAM8x32.WORD[1].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[1].W.B0.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[1].W.B0.BIT[4].OBUF
+ SLICE[3].RAM8x32.WORD[1].W.B0.q_wire[4] SLICE[3].RAM8x32.WORD[1].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[4] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[1].W.B0.BIT[5].LATCH SLICE[0].RAM8x32.Di[5]
+ SLICE[3].RAM8x32.WORD[1].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[1].W.B0.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[1].W.B0.BIT[5].OBUF
+ SLICE[3].RAM8x32.WORD[1].W.B0.q_wire[5] SLICE[3].RAM8x32.WORD[1].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[5] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[1].W.B0.BIT[6].LATCH SLICE[0].RAM8x32.Di[6]
+ SLICE[3].RAM8x32.WORD[1].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[1].W.B0.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[1].W.B0.BIT[6].OBUF
+ SLICE[3].RAM8x32.WORD[1].W.B0.q_wire[6] SLICE[3].RAM8x32.WORD[1].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[6] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[1].W.B0.BIT[7].LATCH SLICE[0].RAM8x32.Di[7]
+ SLICE[3].RAM8x32.WORD[1].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[1].W.B0.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[1].W.B0.BIT[7].OBUF
+ SLICE[3].RAM8x32.WORD[1].W.B0.q_wire[7] SLICE[3].RAM8x32.WORD[1].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[7] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[1].W.B0.CG SLICE[3].RAM8x32.WORD[1].W.B0.CLK_B
+ SLICE[3].RAM8x32.WORD[1].W.B0.we_wire VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[1].W.B0.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[3].RAM8x32.WORD[1].W.B0.CGAND SLICE[3].RAM8x32.WORD[1].W.B0.SEL
+ SLICE[3].RAM8x32.WORD[0].W.B0.WE VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[1].W.B0.we_wire sky130_fd_sc_hd__and2_1
XSLICE[3].RAM8x32.WORD[1].W.B0.CLKINV SLICE[3].RAM8x32.WORD[1].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[1].W.B0.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[1].W.B0.SELINV SLICE[3].RAM8x32.WORD[1].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[1].W.B0.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[1].W.B1.BIT[0].LATCH SLICE[0].RAM8x32.Di[8]
+ SLICE[3].RAM8x32.WORD[1].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[1].W.B1.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[1].W.B1.BIT[0].OBUF
+ SLICE[3].RAM8x32.WORD[1].W.B1.q_wire[0] SLICE[3].RAM8x32.WORD[1].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[8] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[1].W.B1.BIT[1].LATCH SLICE[0].RAM8x32.Di[9]
+ SLICE[3].RAM8x32.WORD[1].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[1].W.B1.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[1].W.B1.BIT[1].OBUF
+ SLICE[3].RAM8x32.WORD[1].W.B1.q_wire[1] SLICE[3].RAM8x32.WORD[1].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[9] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[1].W.B1.BIT[2].LATCH SLICE[0].RAM8x32.Di[10]
+ SLICE[3].RAM8x32.WORD[1].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[1].W.B1.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[1].W.B1.BIT[2].OBUF
+ SLICE[3].RAM8x32.WORD[1].W.B1.q_wire[2] SLICE[3].RAM8x32.WORD[1].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[10] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[1].W.B1.BIT[3].LATCH SLICE[0].RAM8x32.Di[11]
+ SLICE[3].RAM8x32.WORD[1].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[1].W.B1.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[1].W.B1.BIT[3].OBUF
+ SLICE[3].RAM8x32.WORD[1].W.B1.q_wire[3] SLICE[3].RAM8x32.WORD[1].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[11] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[1].W.B1.BIT[4].LATCH SLICE[0].RAM8x32.Di[12]
+ SLICE[3].RAM8x32.WORD[1].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[1].W.B1.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[1].W.B1.BIT[4].OBUF
+ SLICE[3].RAM8x32.WORD[1].W.B1.q_wire[4] SLICE[3].RAM8x32.WORD[1].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[12] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[1].W.B1.BIT[5].LATCH SLICE[0].RAM8x32.Di[13]
+ SLICE[3].RAM8x32.WORD[1].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[1].W.B1.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[1].W.B1.BIT[5].OBUF
+ SLICE[3].RAM8x32.WORD[1].W.B1.q_wire[5] SLICE[3].RAM8x32.WORD[1].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[13] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[1].W.B1.BIT[6].LATCH SLICE[0].RAM8x32.Di[14]
+ SLICE[3].RAM8x32.WORD[1].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[1].W.B1.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[1].W.B1.BIT[6].OBUF
+ SLICE[3].RAM8x32.WORD[1].W.B1.q_wire[6] SLICE[3].RAM8x32.WORD[1].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[14] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[1].W.B1.BIT[7].LATCH SLICE[0].RAM8x32.Di[15]
+ SLICE[3].RAM8x32.WORD[1].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[1].W.B1.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[1].W.B1.BIT[7].OBUF
+ SLICE[3].RAM8x32.WORD[1].W.B1.q_wire[7] SLICE[3].RAM8x32.WORD[1].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[15] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[1].W.B1.CG SLICE[3].RAM8x32.WORD[1].W.B1.CLK_B
+ SLICE[3].RAM8x32.WORD[1].W.B1.we_wire VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[1].W.B1.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[3].RAM8x32.WORD[1].W.B1.CGAND SLICE[3].RAM8x32.WORD[1].W.B0.SEL
+ SLICE[3].RAM8x32.WORD[0].W.B1.WE VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[1].W.B1.we_wire sky130_fd_sc_hd__and2_1
XSLICE[3].RAM8x32.WORD[1].W.B1.CLKINV SLICE[3].RAM8x32.WORD[1].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[1].W.B1.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[1].W.B1.SELINV SLICE[3].RAM8x32.WORD[1].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[1].W.B1.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[1].W.B2.BIT[0].LATCH SLICE[0].RAM8x32.Di[16]
+ SLICE[3].RAM8x32.WORD[1].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[1].W.B2.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[1].W.B2.BIT[0].OBUF
+ SLICE[3].RAM8x32.WORD[1].W.B2.q_wire[0] SLICE[3].RAM8x32.WORD[1].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[16] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[1].W.B2.BIT[1].LATCH SLICE[0].RAM8x32.Di[17]
+ SLICE[3].RAM8x32.WORD[1].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[1].W.B2.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[1].W.B2.BIT[1].OBUF
+ SLICE[3].RAM8x32.WORD[1].W.B2.q_wire[1] SLICE[3].RAM8x32.WORD[1].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[17] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[1].W.B2.BIT[2].LATCH SLICE[0].RAM8x32.Di[18]
+ SLICE[3].RAM8x32.WORD[1].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[1].W.B2.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[1].W.B2.BIT[2].OBUF
+ SLICE[3].RAM8x32.WORD[1].W.B2.q_wire[2] SLICE[3].RAM8x32.WORD[1].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[18] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[1].W.B2.BIT[3].LATCH SLICE[0].RAM8x32.Di[19]
+ SLICE[3].RAM8x32.WORD[1].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[1].W.B2.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[1].W.B2.BIT[3].OBUF
+ SLICE[3].RAM8x32.WORD[1].W.B2.q_wire[3] SLICE[3].RAM8x32.WORD[1].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[19] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[1].W.B2.BIT[4].LATCH SLICE[0].RAM8x32.Di[20]
+ SLICE[3].RAM8x32.WORD[1].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[1].W.B2.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[1].W.B2.BIT[4].OBUF
+ SLICE[3].RAM8x32.WORD[1].W.B2.q_wire[4] SLICE[3].RAM8x32.WORD[1].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[20] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[1].W.B2.BIT[5].LATCH SLICE[0].RAM8x32.Di[21]
+ SLICE[3].RAM8x32.WORD[1].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[1].W.B2.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[1].W.B2.BIT[5].OBUF
+ SLICE[3].RAM8x32.WORD[1].W.B2.q_wire[5] SLICE[3].RAM8x32.WORD[1].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[21] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[1].W.B2.BIT[6].LATCH SLICE[0].RAM8x32.Di[22]
+ SLICE[3].RAM8x32.WORD[1].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[1].W.B2.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[1].W.B2.BIT[6].OBUF
+ SLICE[3].RAM8x32.WORD[1].W.B2.q_wire[6] SLICE[3].RAM8x32.WORD[1].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[22] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[1].W.B2.BIT[7].LATCH SLICE[0].RAM8x32.Di[23]
+ SLICE[3].RAM8x32.WORD[1].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[1].W.B2.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[1].W.B2.BIT[7].OBUF
+ SLICE[3].RAM8x32.WORD[1].W.B2.q_wire[7] SLICE[3].RAM8x32.WORD[1].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[23] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[1].W.B2.CG SLICE[3].RAM8x32.WORD[1].W.B2.CLK_B
+ SLICE[3].RAM8x32.WORD[1].W.B2.we_wire VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[1].W.B2.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[3].RAM8x32.WORD[1].W.B2.CGAND SLICE[3].RAM8x32.WORD[1].W.B0.SEL
+ SLICE[3].RAM8x32.WORD[0].W.B2.WE VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[1].W.B2.we_wire sky130_fd_sc_hd__and2_1
XSLICE[3].RAM8x32.WORD[1].W.B2.CLKINV SLICE[3].RAM8x32.WORD[1].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[1].W.B2.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[1].W.B2.SELINV SLICE[3].RAM8x32.WORD[1].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[1].W.B2.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[1].W.B3.BIT[0].LATCH SLICE[0].RAM8x32.Di[24]
+ SLICE[3].RAM8x32.WORD[1].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[1].W.B3.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[1].W.B3.BIT[0].OBUF
+ SLICE[3].RAM8x32.WORD[1].W.B3.q_wire[0] SLICE[3].RAM8x32.WORD[1].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[24] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[1].W.B3.BIT[1].LATCH SLICE[0].RAM8x32.Di[25]
+ SLICE[3].RAM8x32.WORD[1].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[1].W.B3.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[1].W.B3.BIT[1].OBUF
+ SLICE[3].RAM8x32.WORD[1].W.B3.q_wire[1] SLICE[3].RAM8x32.WORD[1].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[25] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[1].W.B3.BIT[2].LATCH SLICE[0].RAM8x32.Di[26]
+ SLICE[3].RAM8x32.WORD[1].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[1].W.B3.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[1].W.B3.BIT[2].OBUF
+ SLICE[3].RAM8x32.WORD[1].W.B3.q_wire[2] SLICE[3].RAM8x32.WORD[1].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[26] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[1].W.B3.BIT[3].LATCH SLICE[0].RAM8x32.Di[27]
+ SLICE[3].RAM8x32.WORD[1].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[1].W.B3.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[1].W.B3.BIT[3].OBUF
+ SLICE[3].RAM8x32.WORD[1].W.B3.q_wire[3] SLICE[3].RAM8x32.WORD[1].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[27] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[1].W.B3.BIT[4].LATCH SLICE[0].RAM8x32.Di[28]
+ SLICE[3].RAM8x32.WORD[1].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[1].W.B3.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[1].W.B3.BIT[4].OBUF
+ SLICE[3].RAM8x32.WORD[1].W.B3.q_wire[4] SLICE[3].RAM8x32.WORD[1].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[28] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[1].W.B3.BIT[5].LATCH SLICE[0].RAM8x32.Di[29]
+ SLICE[3].RAM8x32.WORD[1].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[1].W.B3.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[1].W.B3.BIT[5].OBUF
+ SLICE[3].RAM8x32.WORD[1].W.B3.q_wire[5] SLICE[3].RAM8x32.WORD[1].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[29] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[1].W.B3.BIT[6].LATCH SLICE[0].RAM8x32.Di[30]
+ SLICE[3].RAM8x32.WORD[1].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[1].W.B3.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[1].W.B3.BIT[6].OBUF
+ SLICE[3].RAM8x32.WORD[1].W.B3.q_wire[6] SLICE[3].RAM8x32.WORD[1].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[30] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[1].W.B3.BIT[7].LATCH SLICE[0].RAM8x32.Di[31]
+ SLICE[3].RAM8x32.WORD[1].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[1].W.B3.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[1].W.B3.BIT[7].OBUF
+ SLICE[3].RAM8x32.WORD[1].W.B3.q_wire[7] SLICE[3].RAM8x32.WORD[1].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[31] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[1].W.B3.CG SLICE[3].RAM8x32.WORD[1].W.B3.CLK_B
+ SLICE[3].RAM8x32.WORD[1].W.B3.we_wire VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[1].W.B3.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[3].RAM8x32.WORD[1].W.B3.CGAND SLICE[3].RAM8x32.WORD[1].W.B0.SEL
+ SLICE[3].RAM8x32.WORD[0].W.B3.WE VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[1].W.B3.we_wire sky130_fd_sc_hd__and2_1
XSLICE[3].RAM8x32.WORD[1].W.B3.CLKINV SLICE[3].RAM8x32.WORD[1].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[1].W.B3.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[1].W.B3.SELINV SLICE[3].RAM8x32.WORD[1].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[1].W.B3.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[1].W.CLKBUF SLICE[3].RAM8x32.CLK_buf VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[1].W.B0.CLK sky130_fd_sc_hd__clkbuf_1
XSLICE[3].RAM8x32.WORD[1].W.SELBUF SLICE[3].RAM8x32.WORD[1].W.SEL VGND VGND
+ VPWR VPWR SLICE[3].RAM8x32.WORD[1].W.B0.SEL sky130_fd_sc_hd__clkbuf_2
XSLICE[3].RAM8x32.WORD[2].W.B0.BIT[0].LATCH SLICE[0].RAM8x32.Di[0]
+ SLICE[3].RAM8x32.WORD[2].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[2].W.B0.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[2].W.B0.BIT[0].OBUF
+ SLICE[3].RAM8x32.WORD[2].W.B0.q_wire[0] SLICE[3].RAM8x32.WORD[2].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[0] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[2].W.B0.BIT[1].LATCH SLICE[0].RAM8x32.Di[1]
+ SLICE[3].RAM8x32.WORD[2].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[2].W.B0.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[2].W.B0.BIT[1].OBUF
+ SLICE[3].RAM8x32.WORD[2].W.B0.q_wire[1] SLICE[3].RAM8x32.WORD[2].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[1] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[2].W.B0.BIT[2].LATCH SLICE[0].RAM8x32.Di[2]
+ SLICE[3].RAM8x32.WORD[2].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[2].W.B0.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[2].W.B0.BIT[2].OBUF
+ SLICE[3].RAM8x32.WORD[2].W.B0.q_wire[2] SLICE[3].RAM8x32.WORD[2].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[2] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[2].W.B0.BIT[3].LATCH SLICE[0].RAM8x32.Di[3]
+ SLICE[3].RAM8x32.WORD[2].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[2].W.B0.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[2].W.B0.BIT[3].OBUF
+ SLICE[3].RAM8x32.WORD[2].W.B0.q_wire[3] SLICE[3].RAM8x32.WORD[2].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[3] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[2].W.B0.BIT[4].LATCH SLICE[0].RAM8x32.Di[4]
+ SLICE[3].RAM8x32.WORD[2].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[2].W.B0.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[2].W.B0.BIT[4].OBUF
+ SLICE[3].RAM8x32.WORD[2].W.B0.q_wire[4] SLICE[3].RAM8x32.WORD[2].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[4] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[2].W.B0.BIT[5].LATCH SLICE[0].RAM8x32.Di[5]
+ SLICE[3].RAM8x32.WORD[2].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[2].W.B0.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[2].W.B0.BIT[5].OBUF
+ SLICE[3].RAM8x32.WORD[2].W.B0.q_wire[5] SLICE[3].RAM8x32.WORD[2].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[5] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[2].W.B0.BIT[6].LATCH SLICE[0].RAM8x32.Di[6]
+ SLICE[3].RAM8x32.WORD[2].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[2].W.B0.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[2].W.B0.BIT[6].OBUF
+ SLICE[3].RAM8x32.WORD[2].W.B0.q_wire[6] SLICE[3].RAM8x32.WORD[2].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[6] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[2].W.B0.BIT[7].LATCH SLICE[0].RAM8x32.Di[7]
+ SLICE[3].RAM8x32.WORD[2].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[2].W.B0.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[2].W.B0.BIT[7].OBUF
+ SLICE[3].RAM8x32.WORD[2].W.B0.q_wire[7] SLICE[3].RAM8x32.WORD[2].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[7] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[2].W.B0.CG SLICE[3].RAM8x32.WORD[2].W.B0.CLK_B
+ SLICE[3].RAM8x32.WORD[2].W.B0.we_wire VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[2].W.B0.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[3].RAM8x32.WORD[2].W.B0.CGAND SLICE[3].RAM8x32.WORD[2].W.B0.SEL
+ SLICE[3].RAM8x32.WORD[0].W.B0.WE VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[2].W.B0.we_wire sky130_fd_sc_hd__and2_1
XSLICE[3].RAM8x32.WORD[2].W.B0.CLKINV SLICE[3].RAM8x32.WORD[2].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[2].W.B0.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[2].W.B0.SELINV SLICE[3].RAM8x32.WORD[2].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[2].W.B0.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[2].W.B1.BIT[0].LATCH SLICE[0].RAM8x32.Di[8]
+ SLICE[3].RAM8x32.WORD[2].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[2].W.B1.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[2].W.B1.BIT[0].OBUF
+ SLICE[3].RAM8x32.WORD[2].W.B1.q_wire[0] SLICE[3].RAM8x32.WORD[2].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[8] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[2].W.B1.BIT[1].LATCH SLICE[0].RAM8x32.Di[9]
+ SLICE[3].RAM8x32.WORD[2].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[2].W.B1.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[2].W.B1.BIT[1].OBUF
+ SLICE[3].RAM8x32.WORD[2].W.B1.q_wire[1] SLICE[3].RAM8x32.WORD[2].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[9] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[2].W.B1.BIT[2].LATCH SLICE[0].RAM8x32.Di[10]
+ SLICE[3].RAM8x32.WORD[2].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[2].W.B1.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[2].W.B1.BIT[2].OBUF
+ SLICE[3].RAM8x32.WORD[2].W.B1.q_wire[2] SLICE[3].RAM8x32.WORD[2].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[10] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[2].W.B1.BIT[3].LATCH SLICE[0].RAM8x32.Di[11]
+ SLICE[3].RAM8x32.WORD[2].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[2].W.B1.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[2].W.B1.BIT[3].OBUF
+ SLICE[3].RAM8x32.WORD[2].W.B1.q_wire[3] SLICE[3].RAM8x32.WORD[2].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[11] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[2].W.B1.BIT[4].LATCH SLICE[0].RAM8x32.Di[12]
+ SLICE[3].RAM8x32.WORD[2].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[2].W.B1.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[2].W.B1.BIT[4].OBUF
+ SLICE[3].RAM8x32.WORD[2].W.B1.q_wire[4] SLICE[3].RAM8x32.WORD[2].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[12] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[2].W.B1.BIT[5].LATCH SLICE[0].RAM8x32.Di[13]
+ SLICE[3].RAM8x32.WORD[2].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[2].W.B1.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[2].W.B1.BIT[5].OBUF
+ SLICE[3].RAM8x32.WORD[2].W.B1.q_wire[5] SLICE[3].RAM8x32.WORD[2].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[13] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[2].W.B1.BIT[6].LATCH SLICE[0].RAM8x32.Di[14]
+ SLICE[3].RAM8x32.WORD[2].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[2].W.B1.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[2].W.B1.BIT[6].OBUF
+ SLICE[3].RAM8x32.WORD[2].W.B1.q_wire[6] SLICE[3].RAM8x32.WORD[2].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[14] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[2].W.B1.BIT[7].LATCH SLICE[0].RAM8x32.Di[15]
+ SLICE[3].RAM8x32.WORD[2].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[2].W.B1.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[2].W.B1.BIT[7].OBUF
+ SLICE[3].RAM8x32.WORD[2].W.B1.q_wire[7] SLICE[3].RAM8x32.WORD[2].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[15] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[2].W.B1.CG SLICE[3].RAM8x32.WORD[2].W.B1.CLK_B
+ SLICE[3].RAM8x32.WORD[2].W.B1.we_wire VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[2].W.B1.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[3].RAM8x32.WORD[2].W.B1.CGAND SLICE[3].RAM8x32.WORD[2].W.B0.SEL
+ SLICE[3].RAM8x32.WORD[0].W.B1.WE VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[2].W.B1.we_wire sky130_fd_sc_hd__and2_1
XSLICE[3].RAM8x32.WORD[2].W.B1.CLKINV SLICE[3].RAM8x32.WORD[2].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[2].W.B1.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[2].W.B1.SELINV SLICE[3].RAM8x32.WORD[2].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[2].W.B1.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[2].W.B2.BIT[0].LATCH SLICE[0].RAM8x32.Di[16]
+ SLICE[3].RAM8x32.WORD[2].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[2].W.B2.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[2].W.B2.BIT[0].OBUF
+ SLICE[3].RAM8x32.WORD[2].W.B2.q_wire[0] SLICE[3].RAM8x32.WORD[2].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[16] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[2].W.B2.BIT[1].LATCH SLICE[0].RAM8x32.Di[17]
+ SLICE[3].RAM8x32.WORD[2].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[2].W.B2.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[2].W.B2.BIT[1].OBUF
+ SLICE[3].RAM8x32.WORD[2].W.B2.q_wire[1] SLICE[3].RAM8x32.WORD[2].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[17] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[2].W.B2.BIT[2].LATCH SLICE[0].RAM8x32.Di[18]
+ SLICE[3].RAM8x32.WORD[2].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[2].W.B2.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[2].W.B2.BIT[2].OBUF
+ SLICE[3].RAM8x32.WORD[2].W.B2.q_wire[2] SLICE[3].RAM8x32.WORD[2].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[18] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[2].W.B2.BIT[3].LATCH SLICE[0].RAM8x32.Di[19]
+ SLICE[3].RAM8x32.WORD[2].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[2].W.B2.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[2].W.B2.BIT[3].OBUF
+ SLICE[3].RAM8x32.WORD[2].W.B2.q_wire[3] SLICE[3].RAM8x32.WORD[2].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[19] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[2].W.B2.BIT[4].LATCH SLICE[0].RAM8x32.Di[20]
+ SLICE[3].RAM8x32.WORD[2].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[2].W.B2.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[2].W.B2.BIT[4].OBUF
+ SLICE[3].RAM8x32.WORD[2].W.B2.q_wire[4] SLICE[3].RAM8x32.WORD[2].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[20] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[2].W.B2.BIT[5].LATCH SLICE[0].RAM8x32.Di[21]
+ SLICE[3].RAM8x32.WORD[2].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[2].W.B2.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[2].W.B2.BIT[5].OBUF
+ SLICE[3].RAM8x32.WORD[2].W.B2.q_wire[5] SLICE[3].RAM8x32.WORD[2].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[21] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[2].W.B2.BIT[6].LATCH SLICE[0].RAM8x32.Di[22]
+ SLICE[3].RAM8x32.WORD[2].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[2].W.B2.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[2].W.B2.BIT[6].OBUF
+ SLICE[3].RAM8x32.WORD[2].W.B2.q_wire[6] SLICE[3].RAM8x32.WORD[2].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[22] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[2].W.B2.BIT[7].LATCH SLICE[0].RAM8x32.Di[23]
+ SLICE[3].RAM8x32.WORD[2].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[2].W.B2.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[2].W.B2.BIT[7].OBUF
+ SLICE[3].RAM8x32.WORD[2].W.B2.q_wire[7] SLICE[3].RAM8x32.WORD[2].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[23] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[2].W.B2.CG SLICE[3].RAM8x32.WORD[2].W.B2.CLK_B
+ SLICE[3].RAM8x32.WORD[2].W.B2.we_wire VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[2].W.B2.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[3].RAM8x32.WORD[2].W.B2.CGAND SLICE[3].RAM8x32.WORD[2].W.B0.SEL
+ SLICE[3].RAM8x32.WORD[0].W.B2.WE VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[2].W.B2.we_wire sky130_fd_sc_hd__and2_1
XSLICE[3].RAM8x32.WORD[2].W.B2.CLKINV SLICE[3].RAM8x32.WORD[2].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[2].W.B2.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[2].W.B2.SELINV SLICE[3].RAM8x32.WORD[2].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[2].W.B2.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[2].W.B3.BIT[0].LATCH SLICE[0].RAM8x32.Di[24]
+ SLICE[3].RAM8x32.WORD[2].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[2].W.B3.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[2].W.B3.BIT[0].OBUF
+ SLICE[3].RAM8x32.WORD[2].W.B3.q_wire[0] SLICE[3].RAM8x32.WORD[2].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[24] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[2].W.B3.BIT[1].LATCH SLICE[0].RAM8x32.Di[25]
+ SLICE[3].RAM8x32.WORD[2].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[2].W.B3.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[2].W.B3.BIT[1].OBUF
+ SLICE[3].RAM8x32.WORD[2].W.B3.q_wire[1] SLICE[3].RAM8x32.WORD[2].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[25] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[2].W.B3.BIT[2].LATCH SLICE[0].RAM8x32.Di[26]
+ SLICE[3].RAM8x32.WORD[2].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[2].W.B3.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[2].W.B3.BIT[2].OBUF
+ SLICE[3].RAM8x32.WORD[2].W.B3.q_wire[2] SLICE[3].RAM8x32.WORD[2].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[26] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[2].W.B3.BIT[3].LATCH SLICE[0].RAM8x32.Di[27]
+ SLICE[3].RAM8x32.WORD[2].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[2].W.B3.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[2].W.B3.BIT[3].OBUF
+ SLICE[3].RAM8x32.WORD[2].W.B3.q_wire[3] SLICE[3].RAM8x32.WORD[2].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[27] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[2].W.B3.BIT[4].LATCH SLICE[0].RAM8x32.Di[28]
+ SLICE[3].RAM8x32.WORD[2].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[2].W.B3.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[2].W.B3.BIT[4].OBUF
+ SLICE[3].RAM8x32.WORD[2].W.B3.q_wire[4] SLICE[3].RAM8x32.WORD[2].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[28] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[2].W.B3.BIT[5].LATCH SLICE[0].RAM8x32.Di[29]
+ SLICE[3].RAM8x32.WORD[2].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[2].W.B3.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[2].W.B3.BIT[5].OBUF
+ SLICE[3].RAM8x32.WORD[2].W.B3.q_wire[5] SLICE[3].RAM8x32.WORD[2].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[29] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[2].W.B3.BIT[6].LATCH SLICE[0].RAM8x32.Di[30]
+ SLICE[3].RAM8x32.WORD[2].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[2].W.B3.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[2].W.B3.BIT[6].OBUF
+ SLICE[3].RAM8x32.WORD[2].W.B3.q_wire[6] SLICE[3].RAM8x32.WORD[2].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[30] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[2].W.B3.BIT[7].LATCH SLICE[0].RAM8x32.Di[31]
+ SLICE[3].RAM8x32.WORD[2].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[2].W.B3.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[2].W.B3.BIT[7].OBUF
+ SLICE[3].RAM8x32.WORD[2].W.B3.q_wire[7] SLICE[3].RAM8x32.WORD[2].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[31] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[2].W.B3.CG SLICE[3].RAM8x32.WORD[2].W.B3.CLK_B
+ SLICE[3].RAM8x32.WORD[2].W.B3.we_wire VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[2].W.B3.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[3].RAM8x32.WORD[2].W.B3.CGAND SLICE[3].RAM8x32.WORD[2].W.B0.SEL
+ SLICE[3].RAM8x32.WORD[0].W.B3.WE VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[2].W.B3.we_wire sky130_fd_sc_hd__and2_1
XSLICE[3].RAM8x32.WORD[2].W.B3.CLKINV SLICE[3].RAM8x32.WORD[2].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[2].W.B3.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[2].W.B3.SELINV SLICE[3].RAM8x32.WORD[2].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[2].W.B3.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[2].W.CLKBUF SLICE[3].RAM8x32.CLK_buf VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[2].W.B0.CLK sky130_fd_sc_hd__clkbuf_1
XSLICE[3].RAM8x32.WORD[2].W.SELBUF SLICE[3].RAM8x32.WORD[2].W.SEL VGND VGND
+ VPWR VPWR SLICE[3].RAM8x32.WORD[2].W.B0.SEL sky130_fd_sc_hd__clkbuf_2
XSLICE[3].RAM8x32.WORD[3].W.B0.BIT[0].LATCH SLICE[0].RAM8x32.Di[0]
+ SLICE[3].RAM8x32.WORD[3].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[3].W.B0.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[3].W.B0.BIT[0].OBUF
+ SLICE[3].RAM8x32.WORD[3].W.B0.q_wire[0] SLICE[3].RAM8x32.WORD[3].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[0] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[3].W.B0.BIT[1].LATCH SLICE[0].RAM8x32.Di[1]
+ SLICE[3].RAM8x32.WORD[3].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[3].W.B0.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[3].W.B0.BIT[1].OBUF
+ SLICE[3].RAM8x32.WORD[3].W.B0.q_wire[1] SLICE[3].RAM8x32.WORD[3].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[1] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[3].W.B0.BIT[2].LATCH SLICE[0].RAM8x32.Di[2]
+ SLICE[3].RAM8x32.WORD[3].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[3].W.B0.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[3].W.B0.BIT[2].OBUF
+ SLICE[3].RAM8x32.WORD[3].W.B0.q_wire[2] SLICE[3].RAM8x32.WORD[3].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[2] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[3].W.B0.BIT[3].LATCH SLICE[0].RAM8x32.Di[3]
+ SLICE[3].RAM8x32.WORD[3].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[3].W.B0.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[3].W.B0.BIT[3].OBUF
+ SLICE[3].RAM8x32.WORD[3].W.B0.q_wire[3] SLICE[3].RAM8x32.WORD[3].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[3] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[3].W.B0.BIT[4].LATCH SLICE[0].RAM8x32.Di[4]
+ SLICE[3].RAM8x32.WORD[3].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[3].W.B0.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[3].W.B0.BIT[4].OBUF
+ SLICE[3].RAM8x32.WORD[3].W.B0.q_wire[4] SLICE[3].RAM8x32.WORD[3].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[4] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[3].W.B0.BIT[5].LATCH SLICE[0].RAM8x32.Di[5]
+ SLICE[3].RAM8x32.WORD[3].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[3].W.B0.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[3].W.B0.BIT[5].OBUF
+ SLICE[3].RAM8x32.WORD[3].W.B0.q_wire[5] SLICE[3].RAM8x32.WORD[3].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[5] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[3].W.B0.BIT[6].LATCH SLICE[0].RAM8x32.Di[6]
+ SLICE[3].RAM8x32.WORD[3].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[3].W.B0.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[3].W.B0.BIT[6].OBUF
+ SLICE[3].RAM8x32.WORD[3].W.B0.q_wire[6] SLICE[3].RAM8x32.WORD[3].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[6] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[3].W.B0.BIT[7].LATCH SLICE[0].RAM8x32.Di[7]
+ SLICE[3].RAM8x32.WORD[3].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[3].W.B0.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[3].W.B0.BIT[7].OBUF
+ SLICE[3].RAM8x32.WORD[3].W.B0.q_wire[7] SLICE[3].RAM8x32.WORD[3].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[7] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[3].W.B0.CG SLICE[3].RAM8x32.WORD[3].W.B0.CLK_B
+ SLICE[3].RAM8x32.WORD[3].W.B0.we_wire VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[3].W.B0.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[3].RAM8x32.WORD[3].W.B0.CGAND SLICE[3].RAM8x32.WORD[3].W.B0.SEL
+ SLICE[3].RAM8x32.WORD[0].W.B0.WE VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[3].W.B0.we_wire sky130_fd_sc_hd__and2_1
XSLICE[3].RAM8x32.WORD[3].W.B0.CLKINV SLICE[3].RAM8x32.WORD[3].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[3].W.B0.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[3].W.B0.SELINV SLICE[3].RAM8x32.WORD[3].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[3].W.B0.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[3].W.B1.BIT[0].LATCH SLICE[0].RAM8x32.Di[8]
+ SLICE[3].RAM8x32.WORD[3].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[3].W.B1.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[3].W.B1.BIT[0].OBUF
+ SLICE[3].RAM8x32.WORD[3].W.B1.q_wire[0] SLICE[3].RAM8x32.WORD[3].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[8] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[3].W.B1.BIT[1].LATCH SLICE[0].RAM8x32.Di[9]
+ SLICE[3].RAM8x32.WORD[3].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[3].W.B1.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[3].W.B1.BIT[1].OBUF
+ SLICE[3].RAM8x32.WORD[3].W.B1.q_wire[1] SLICE[3].RAM8x32.WORD[3].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[9] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[3].W.B1.BIT[2].LATCH SLICE[0].RAM8x32.Di[10]
+ SLICE[3].RAM8x32.WORD[3].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[3].W.B1.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[3].W.B1.BIT[2].OBUF
+ SLICE[3].RAM8x32.WORD[3].W.B1.q_wire[2] SLICE[3].RAM8x32.WORD[3].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[10] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[3].W.B1.BIT[3].LATCH SLICE[0].RAM8x32.Di[11]
+ SLICE[3].RAM8x32.WORD[3].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[3].W.B1.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[3].W.B1.BIT[3].OBUF
+ SLICE[3].RAM8x32.WORD[3].W.B1.q_wire[3] SLICE[3].RAM8x32.WORD[3].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[11] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[3].W.B1.BIT[4].LATCH SLICE[0].RAM8x32.Di[12]
+ SLICE[3].RAM8x32.WORD[3].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[3].W.B1.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[3].W.B1.BIT[4].OBUF
+ SLICE[3].RAM8x32.WORD[3].W.B1.q_wire[4] SLICE[3].RAM8x32.WORD[3].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[12] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[3].W.B1.BIT[5].LATCH SLICE[0].RAM8x32.Di[13]
+ SLICE[3].RAM8x32.WORD[3].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[3].W.B1.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[3].W.B1.BIT[5].OBUF
+ SLICE[3].RAM8x32.WORD[3].W.B1.q_wire[5] SLICE[3].RAM8x32.WORD[3].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[13] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[3].W.B1.BIT[6].LATCH SLICE[0].RAM8x32.Di[14]
+ SLICE[3].RAM8x32.WORD[3].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[3].W.B1.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[3].W.B1.BIT[6].OBUF
+ SLICE[3].RAM8x32.WORD[3].W.B1.q_wire[6] SLICE[3].RAM8x32.WORD[3].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[14] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[3].W.B1.BIT[7].LATCH SLICE[0].RAM8x32.Di[15]
+ SLICE[3].RAM8x32.WORD[3].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[3].W.B1.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[3].W.B1.BIT[7].OBUF
+ SLICE[3].RAM8x32.WORD[3].W.B1.q_wire[7] SLICE[3].RAM8x32.WORD[3].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[15] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[3].W.B1.CG SLICE[3].RAM8x32.WORD[3].W.B1.CLK_B
+ SLICE[3].RAM8x32.WORD[3].W.B1.we_wire VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[3].W.B1.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[3].RAM8x32.WORD[3].W.B1.CGAND SLICE[3].RAM8x32.WORD[3].W.B0.SEL
+ SLICE[3].RAM8x32.WORD[0].W.B1.WE VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[3].W.B1.we_wire sky130_fd_sc_hd__and2_1
XSLICE[3].RAM8x32.WORD[3].W.B1.CLKINV SLICE[3].RAM8x32.WORD[3].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[3].W.B1.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[3].W.B1.SELINV SLICE[3].RAM8x32.WORD[3].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[3].W.B1.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[3].W.B2.BIT[0].LATCH SLICE[0].RAM8x32.Di[16]
+ SLICE[3].RAM8x32.WORD[3].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[3].W.B2.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[3].W.B2.BIT[0].OBUF
+ SLICE[3].RAM8x32.WORD[3].W.B2.q_wire[0] SLICE[3].RAM8x32.WORD[3].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[16] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[3].W.B2.BIT[1].LATCH SLICE[0].RAM8x32.Di[17]
+ SLICE[3].RAM8x32.WORD[3].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[3].W.B2.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[3].W.B2.BIT[1].OBUF
+ SLICE[3].RAM8x32.WORD[3].W.B2.q_wire[1] SLICE[3].RAM8x32.WORD[3].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[17] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[3].W.B2.BIT[2].LATCH SLICE[0].RAM8x32.Di[18]
+ SLICE[3].RAM8x32.WORD[3].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[3].W.B2.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[3].W.B2.BIT[2].OBUF
+ SLICE[3].RAM8x32.WORD[3].W.B2.q_wire[2] SLICE[3].RAM8x32.WORD[3].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[18] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[3].W.B2.BIT[3].LATCH SLICE[0].RAM8x32.Di[19]
+ SLICE[3].RAM8x32.WORD[3].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[3].W.B2.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[3].W.B2.BIT[3].OBUF
+ SLICE[3].RAM8x32.WORD[3].W.B2.q_wire[3] SLICE[3].RAM8x32.WORD[3].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[19] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[3].W.B2.BIT[4].LATCH SLICE[0].RAM8x32.Di[20]
+ SLICE[3].RAM8x32.WORD[3].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[3].W.B2.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[3].W.B2.BIT[4].OBUF
+ SLICE[3].RAM8x32.WORD[3].W.B2.q_wire[4] SLICE[3].RAM8x32.WORD[3].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[20] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[3].W.B2.BIT[5].LATCH SLICE[0].RAM8x32.Di[21]
+ SLICE[3].RAM8x32.WORD[3].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[3].W.B2.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[3].W.B2.BIT[5].OBUF
+ SLICE[3].RAM8x32.WORD[3].W.B2.q_wire[5] SLICE[3].RAM8x32.WORD[3].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[21] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[3].W.B2.BIT[6].LATCH SLICE[0].RAM8x32.Di[22]
+ SLICE[3].RAM8x32.WORD[3].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[3].W.B2.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[3].W.B2.BIT[6].OBUF
+ SLICE[3].RAM8x32.WORD[3].W.B2.q_wire[6] SLICE[3].RAM8x32.WORD[3].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[22] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[3].W.B2.BIT[7].LATCH SLICE[0].RAM8x32.Di[23]
+ SLICE[3].RAM8x32.WORD[3].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[3].W.B2.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[3].W.B2.BIT[7].OBUF
+ SLICE[3].RAM8x32.WORD[3].W.B2.q_wire[7] SLICE[3].RAM8x32.WORD[3].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[23] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[3].W.B2.CG SLICE[3].RAM8x32.WORD[3].W.B2.CLK_B
+ SLICE[3].RAM8x32.WORD[3].W.B2.we_wire VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[3].W.B2.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[3].RAM8x32.WORD[3].W.B2.CGAND SLICE[3].RAM8x32.WORD[3].W.B0.SEL
+ SLICE[3].RAM8x32.WORD[0].W.B2.WE VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[3].W.B2.we_wire sky130_fd_sc_hd__and2_1
XSLICE[3].RAM8x32.WORD[3].W.B2.CLKINV SLICE[3].RAM8x32.WORD[3].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[3].W.B2.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[3].W.B2.SELINV SLICE[3].RAM8x32.WORD[3].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[3].W.B2.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[3].W.B3.BIT[0].LATCH SLICE[0].RAM8x32.Di[24]
+ SLICE[3].RAM8x32.WORD[3].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[3].W.B3.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[3].W.B3.BIT[0].OBUF
+ SLICE[3].RAM8x32.WORD[3].W.B3.q_wire[0] SLICE[3].RAM8x32.WORD[3].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[24] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[3].W.B3.BIT[1].LATCH SLICE[0].RAM8x32.Di[25]
+ SLICE[3].RAM8x32.WORD[3].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[3].W.B3.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[3].W.B3.BIT[1].OBUF
+ SLICE[3].RAM8x32.WORD[3].W.B3.q_wire[1] SLICE[3].RAM8x32.WORD[3].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[25] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[3].W.B3.BIT[2].LATCH SLICE[0].RAM8x32.Di[26]
+ SLICE[3].RAM8x32.WORD[3].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[3].W.B3.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[3].W.B3.BIT[2].OBUF
+ SLICE[3].RAM8x32.WORD[3].W.B3.q_wire[2] SLICE[3].RAM8x32.WORD[3].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[26] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[3].W.B3.BIT[3].LATCH SLICE[0].RAM8x32.Di[27]
+ SLICE[3].RAM8x32.WORD[3].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[3].W.B3.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[3].W.B3.BIT[3].OBUF
+ SLICE[3].RAM8x32.WORD[3].W.B3.q_wire[3] SLICE[3].RAM8x32.WORD[3].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[27] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[3].W.B3.BIT[4].LATCH SLICE[0].RAM8x32.Di[28]
+ SLICE[3].RAM8x32.WORD[3].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[3].W.B3.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[3].W.B3.BIT[4].OBUF
+ SLICE[3].RAM8x32.WORD[3].W.B3.q_wire[4] SLICE[3].RAM8x32.WORD[3].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[28] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[3].W.B3.BIT[5].LATCH SLICE[0].RAM8x32.Di[29]
+ SLICE[3].RAM8x32.WORD[3].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[3].W.B3.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[3].W.B3.BIT[5].OBUF
+ SLICE[3].RAM8x32.WORD[3].W.B3.q_wire[5] SLICE[3].RAM8x32.WORD[3].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[29] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[3].W.B3.BIT[6].LATCH SLICE[0].RAM8x32.Di[30]
+ SLICE[3].RAM8x32.WORD[3].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[3].W.B3.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[3].W.B3.BIT[6].OBUF
+ SLICE[3].RAM8x32.WORD[3].W.B3.q_wire[6] SLICE[3].RAM8x32.WORD[3].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[30] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[3].W.B3.BIT[7].LATCH SLICE[0].RAM8x32.Di[31]
+ SLICE[3].RAM8x32.WORD[3].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[3].W.B3.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[3].W.B3.BIT[7].OBUF
+ SLICE[3].RAM8x32.WORD[3].W.B3.q_wire[7] SLICE[3].RAM8x32.WORD[3].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[31] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[3].W.B3.CG SLICE[3].RAM8x32.WORD[3].W.B3.CLK_B
+ SLICE[3].RAM8x32.WORD[3].W.B3.we_wire VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[3].W.B3.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[3].RAM8x32.WORD[3].W.B3.CGAND SLICE[3].RAM8x32.WORD[3].W.B0.SEL
+ SLICE[3].RAM8x32.WORD[0].W.B3.WE VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[3].W.B3.we_wire sky130_fd_sc_hd__and2_1
XSLICE[3].RAM8x32.WORD[3].W.B3.CLKINV SLICE[3].RAM8x32.WORD[3].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[3].W.B3.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[3].W.B3.SELINV SLICE[3].RAM8x32.WORD[3].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[3].W.B3.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[3].W.CLKBUF SLICE[3].RAM8x32.CLK_buf VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[3].W.B0.CLK sky130_fd_sc_hd__clkbuf_1
XSLICE[3].RAM8x32.WORD[3].W.SELBUF SLICE[3].RAM8x32.WORD[3].W.SEL VGND VGND
+ VPWR VPWR SLICE[3].RAM8x32.WORD[3].W.B0.SEL sky130_fd_sc_hd__clkbuf_2
XSLICE[3].RAM8x32.WORD[4].W.B0.BIT[0].LATCH SLICE[0].RAM8x32.Di[0]
+ SLICE[3].RAM8x32.WORD[4].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[4].W.B0.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[4].W.B0.BIT[0].OBUF
+ SLICE[3].RAM8x32.WORD[4].W.B0.q_wire[0] SLICE[3].RAM8x32.WORD[4].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[0] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[4].W.B0.BIT[1].LATCH SLICE[0].RAM8x32.Di[1]
+ SLICE[3].RAM8x32.WORD[4].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[4].W.B0.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[4].W.B0.BIT[1].OBUF
+ SLICE[3].RAM8x32.WORD[4].W.B0.q_wire[1] SLICE[3].RAM8x32.WORD[4].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[1] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[4].W.B0.BIT[2].LATCH SLICE[0].RAM8x32.Di[2]
+ SLICE[3].RAM8x32.WORD[4].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[4].W.B0.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[4].W.B0.BIT[2].OBUF
+ SLICE[3].RAM8x32.WORD[4].W.B0.q_wire[2] SLICE[3].RAM8x32.WORD[4].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[2] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[4].W.B0.BIT[3].LATCH SLICE[0].RAM8x32.Di[3]
+ SLICE[3].RAM8x32.WORD[4].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[4].W.B0.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[4].W.B0.BIT[3].OBUF
+ SLICE[3].RAM8x32.WORD[4].W.B0.q_wire[3] SLICE[3].RAM8x32.WORD[4].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[3] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[4].W.B0.BIT[4].LATCH SLICE[0].RAM8x32.Di[4]
+ SLICE[3].RAM8x32.WORD[4].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[4].W.B0.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[4].W.B0.BIT[4].OBUF
+ SLICE[3].RAM8x32.WORD[4].W.B0.q_wire[4] SLICE[3].RAM8x32.WORD[4].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[4] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[4].W.B0.BIT[5].LATCH SLICE[0].RAM8x32.Di[5]
+ SLICE[3].RAM8x32.WORD[4].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[4].W.B0.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[4].W.B0.BIT[5].OBUF
+ SLICE[3].RAM8x32.WORD[4].W.B0.q_wire[5] SLICE[3].RAM8x32.WORD[4].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[5] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[4].W.B0.BIT[6].LATCH SLICE[0].RAM8x32.Di[6]
+ SLICE[3].RAM8x32.WORD[4].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[4].W.B0.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[4].W.B0.BIT[6].OBUF
+ SLICE[3].RAM8x32.WORD[4].W.B0.q_wire[6] SLICE[3].RAM8x32.WORD[4].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[6] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[4].W.B0.BIT[7].LATCH SLICE[0].RAM8x32.Di[7]
+ SLICE[3].RAM8x32.WORD[4].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[4].W.B0.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[4].W.B0.BIT[7].OBUF
+ SLICE[3].RAM8x32.WORD[4].W.B0.q_wire[7] SLICE[3].RAM8x32.WORD[4].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[7] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[4].W.B0.CG SLICE[3].RAM8x32.WORD[4].W.B0.CLK_B
+ SLICE[3].RAM8x32.WORD[4].W.B0.we_wire VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[4].W.B0.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[3].RAM8x32.WORD[4].W.B0.CGAND SLICE[3].RAM8x32.WORD[4].W.B0.SEL
+ SLICE[3].RAM8x32.WORD[0].W.B0.WE VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[4].W.B0.we_wire sky130_fd_sc_hd__and2_1
XSLICE[3].RAM8x32.WORD[4].W.B0.CLKINV SLICE[3].RAM8x32.WORD[4].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[4].W.B0.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[4].W.B0.SELINV SLICE[3].RAM8x32.WORD[4].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[4].W.B0.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[4].W.B1.BIT[0].LATCH SLICE[0].RAM8x32.Di[8]
+ SLICE[3].RAM8x32.WORD[4].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[4].W.B1.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[4].W.B1.BIT[0].OBUF
+ SLICE[3].RAM8x32.WORD[4].W.B1.q_wire[0] SLICE[3].RAM8x32.WORD[4].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[8] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[4].W.B1.BIT[1].LATCH SLICE[0].RAM8x32.Di[9]
+ SLICE[3].RAM8x32.WORD[4].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[4].W.B1.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[4].W.B1.BIT[1].OBUF
+ SLICE[3].RAM8x32.WORD[4].W.B1.q_wire[1] SLICE[3].RAM8x32.WORD[4].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[9] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[4].W.B1.BIT[2].LATCH SLICE[0].RAM8x32.Di[10]
+ SLICE[3].RAM8x32.WORD[4].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[4].W.B1.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[4].W.B1.BIT[2].OBUF
+ SLICE[3].RAM8x32.WORD[4].W.B1.q_wire[2] SLICE[3].RAM8x32.WORD[4].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[10] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[4].W.B1.BIT[3].LATCH SLICE[0].RAM8x32.Di[11]
+ SLICE[3].RAM8x32.WORD[4].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[4].W.B1.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[4].W.B1.BIT[3].OBUF
+ SLICE[3].RAM8x32.WORD[4].W.B1.q_wire[3] SLICE[3].RAM8x32.WORD[4].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[11] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[4].W.B1.BIT[4].LATCH SLICE[0].RAM8x32.Di[12]
+ SLICE[3].RAM8x32.WORD[4].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[4].W.B1.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[4].W.B1.BIT[4].OBUF
+ SLICE[3].RAM8x32.WORD[4].W.B1.q_wire[4] SLICE[3].RAM8x32.WORD[4].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[12] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[4].W.B1.BIT[5].LATCH SLICE[0].RAM8x32.Di[13]
+ SLICE[3].RAM8x32.WORD[4].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[4].W.B1.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[4].W.B1.BIT[5].OBUF
+ SLICE[3].RAM8x32.WORD[4].W.B1.q_wire[5] SLICE[3].RAM8x32.WORD[4].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[13] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[4].W.B1.BIT[6].LATCH SLICE[0].RAM8x32.Di[14]
+ SLICE[3].RAM8x32.WORD[4].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[4].W.B1.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[4].W.B1.BIT[6].OBUF
+ SLICE[3].RAM8x32.WORD[4].W.B1.q_wire[6] SLICE[3].RAM8x32.WORD[4].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[14] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[4].W.B1.BIT[7].LATCH SLICE[0].RAM8x32.Di[15]
+ SLICE[3].RAM8x32.WORD[4].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[4].W.B1.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[4].W.B1.BIT[7].OBUF
+ SLICE[3].RAM8x32.WORD[4].W.B1.q_wire[7] SLICE[3].RAM8x32.WORD[4].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[15] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[4].W.B1.CG SLICE[3].RAM8x32.WORD[4].W.B1.CLK_B
+ SLICE[3].RAM8x32.WORD[4].W.B1.we_wire VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[4].W.B1.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[3].RAM8x32.WORD[4].W.B1.CGAND SLICE[3].RAM8x32.WORD[4].W.B0.SEL
+ SLICE[3].RAM8x32.WORD[0].W.B1.WE VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[4].W.B1.we_wire sky130_fd_sc_hd__and2_1
XSLICE[3].RAM8x32.WORD[4].W.B1.CLKINV SLICE[3].RAM8x32.WORD[4].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[4].W.B1.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[4].W.B1.SELINV SLICE[3].RAM8x32.WORD[4].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[4].W.B1.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[4].W.B2.BIT[0].LATCH SLICE[0].RAM8x32.Di[16]
+ SLICE[3].RAM8x32.WORD[4].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[4].W.B2.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[4].W.B2.BIT[0].OBUF
+ SLICE[3].RAM8x32.WORD[4].W.B2.q_wire[0] SLICE[3].RAM8x32.WORD[4].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[16] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[4].W.B2.BIT[1].LATCH SLICE[0].RAM8x32.Di[17]
+ SLICE[3].RAM8x32.WORD[4].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[4].W.B2.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[4].W.B2.BIT[1].OBUF
+ SLICE[3].RAM8x32.WORD[4].W.B2.q_wire[1] SLICE[3].RAM8x32.WORD[4].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[17] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[4].W.B2.BIT[2].LATCH SLICE[0].RAM8x32.Di[18]
+ SLICE[3].RAM8x32.WORD[4].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[4].W.B2.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[4].W.B2.BIT[2].OBUF
+ SLICE[3].RAM8x32.WORD[4].W.B2.q_wire[2] SLICE[3].RAM8x32.WORD[4].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[18] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[4].W.B2.BIT[3].LATCH SLICE[0].RAM8x32.Di[19]
+ SLICE[3].RAM8x32.WORD[4].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[4].W.B2.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[4].W.B2.BIT[3].OBUF
+ SLICE[3].RAM8x32.WORD[4].W.B2.q_wire[3] SLICE[3].RAM8x32.WORD[4].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[19] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[4].W.B2.BIT[4].LATCH SLICE[0].RAM8x32.Di[20]
+ SLICE[3].RAM8x32.WORD[4].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[4].W.B2.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[4].W.B2.BIT[4].OBUF
+ SLICE[3].RAM8x32.WORD[4].W.B2.q_wire[4] SLICE[3].RAM8x32.WORD[4].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[20] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[4].W.B2.BIT[5].LATCH SLICE[0].RAM8x32.Di[21]
+ SLICE[3].RAM8x32.WORD[4].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[4].W.B2.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[4].W.B2.BIT[5].OBUF
+ SLICE[3].RAM8x32.WORD[4].W.B2.q_wire[5] SLICE[3].RAM8x32.WORD[4].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[21] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[4].W.B2.BIT[6].LATCH SLICE[0].RAM8x32.Di[22]
+ SLICE[3].RAM8x32.WORD[4].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[4].W.B2.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[4].W.B2.BIT[6].OBUF
+ SLICE[3].RAM8x32.WORD[4].W.B2.q_wire[6] SLICE[3].RAM8x32.WORD[4].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[22] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[4].W.B2.BIT[7].LATCH SLICE[0].RAM8x32.Di[23]
+ SLICE[3].RAM8x32.WORD[4].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[4].W.B2.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[4].W.B2.BIT[7].OBUF
+ SLICE[3].RAM8x32.WORD[4].W.B2.q_wire[7] SLICE[3].RAM8x32.WORD[4].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[23] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[4].W.B2.CG SLICE[3].RAM8x32.WORD[4].W.B2.CLK_B
+ SLICE[3].RAM8x32.WORD[4].W.B2.we_wire VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[4].W.B2.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[3].RAM8x32.WORD[4].W.B2.CGAND SLICE[3].RAM8x32.WORD[4].W.B0.SEL
+ SLICE[3].RAM8x32.WORD[0].W.B2.WE VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[4].W.B2.we_wire sky130_fd_sc_hd__and2_1
XSLICE[3].RAM8x32.WORD[4].W.B2.CLKINV SLICE[3].RAM8x32.WORD[4].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[4].W.B2.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[4].W.B2.SELINV SLICE[3].RAM8x32.WORD[4].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[4].W.B2.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[4].W.B3.BIT[0].LATCH SLICE[0].RAM8x32.Di[24]
+ SLICE[3].RAM8x32.WORD[4].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[4].W.B3.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[4].W.B3.BIT[0].OBUF
+ SLICE[3].RAM8x32.WORD[4].W.B3.q_wire[0] SLICE[3].RAM8x32.WORD[4].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[24] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[4].W.B3.BIT[1].LATCH SLICE[0].RAM8x32.Di[25]
+ SLICE[3].RAM8x32.WORD[4].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[4].W.B3.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[4].W.B3.BIT[1].OBUF
+ SLICE[3].RAM8x32.WORD[4].W.B3.q_wire[1] SLICE[3].RAM8x32.WORD[4].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[25] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[4].W.B3.BIT[2].LATCH SLICE[0].RAM8x32.Di[26]
+ SLICE[3].RAM8x32.WORD[4].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[4].W.B3.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[4].W.B3.BIT[2].OBUF
+ SLICE[3].RAM8x32.WORD[4].W.B3.q_wire[2] SLICE[3].RAM8x32.WORD[4].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[26] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[4].W.B3.BIT[3].LATCH SLICE[0].RAM8x32.Di[27]
+ SLICE[3].RAM8x32.WORD[4].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[4].W.B3.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[4].W.B3.BIT[3].OBUF
+ SLICE[3].RAM8x32.WORD[4].W.B3.q_wire[3] SLICE[3].RAM8x32.WORD[4].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[27] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[4].W.B3.BIT[4].LATCH SLICE[0].RAM8x32.Di[28]
+ SLICE[3].RAM8x32.WORD[4].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[4].W.B3.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[4].W.B3.BIT[4].OBUF
+ SLICE[3].RAM8x32.WORD[4].W.B3.q_wire[4] SLICE[3].RAM8x32.WORD[4].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[28] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[4].W.B3.BIT[5].LATCH SLICE[0].RAM8x32.Di[29]
+ SLICE[3].RAM8x32.WORD[4].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[4].W.B3.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[4].W.B3.BIT[5].OBUF
+ SLICE[3].RAM8x32.WORD[4].W.B3.q_wire[5] SLICE[3].RAM8x32.WORD[4].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[29] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[4].W.B3.BIT[6].LATCH SLICE[0].RAM8x32.Di[30]
+ SLICE[3].RAM8x32.WORD[4].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[4].W.B3.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[4].W.B3.BIT[6].OBUF
+ SLICE[3].RAM8x32.WORD[4].W.B3.q_wire[6] SLICE[3].RAM8x32.WORD[4].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[30] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[4].W.B3.BIT[7].LATCH SLICE[0].RAM8x32.Di[31]
+ SLICE[3].RAM8x32.WORD[4].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[4].W.B3.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[4].W.B3.BIT[7].OBUF
+ SLICE[3].RAM8x32.WORD[4].W.B3.q_wire[7] SLICE[3].RAM8x32.WORD[4].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[31] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[4].W.B3.CG SLICE[3].RAM8x32.WORD[4].W.B3.CLK_B
+ SLICE[3].RAM8x32.WORD[4].W.B3.we_wire VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[4].W.B3.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[3].RAM8x32.WORD[4].W.B3.CGAND SLICE[3].RAM8x32.WORD[4].W.B0.SEL
+ SLICE[3].RAM8x32.WORD[0].W.B3.WE VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[4].W.B3.we_wire sky130_fd_sc_hd__and2_1
XSLICE[3].RAM8x32.WORD[4].W.B3.CLKINV SLICE[3].RAM8x32.WORD[4].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[4].W.B3.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[4].W.B3.SELINV SLICE[3].RAM8x32.WORD[4].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[4].W.B3.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[4].W.CLKBUF SLICE[3].RAM8x32.CLK_buf VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[4].W.B0.CLK sky130_fd_sc_hd__clkbuf_1
XSLICE[3].RAM8x32.WORD[4].W.SELBUF SLICE[3].RAM8x32.WORD[4].W.SEL VGND VGND
+ VPWR VPWR SLICE[3].RAM8x32.WORD[4].W.B0.SEL sky130_fd_sc_hd__clkbuf_2
XSLICE[3].RAM8x32.WORD[5].W.B0.BIT[0].LATCH SLICE[0].RAM8x32.Di[0]
+ SLICE[3].RAM8x32.WORD[5].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[5].W.B0.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[5].W.B0.BIT[0].OBUF
+ SLICE[3].RAM8x32.WORD[5].W.B0.q_wire[0] SLICE[3].RAM8x32.WORD[5].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[0] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[5].W.B0.BIT[1].LATCH SLICE[0].RAM8x32.Di[1]
+ SLICE[3].RAM8x32.WORD[5].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[5].W.B0.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[5].W.B0.BIT[1].OBUF
+ SLICE[3].RAM8x32.WORD[5].W.B0.q_wire[1] SLICE[3].RAM8x32.WORD[5].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[1] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[5].W.B0.BIT[2].LATCH SLICE[0].RAM8x32.Di[2]
+ SLICE[3].RAM8x32.WORD[5].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[5].W.B0.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[5].W.B0.BIT[2].OBUF
+ SLICE[3].RAM8x32.WORD[5].W.B0.q_wire[2] SLICE[3].RAM8x32.WORD[5].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[2] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[5].W.B0.BIT[3].LATCH SLICE[0].RAM8x32.Di[3]
+ SLICE[3].RAM8x32.WORD[5].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[5].W.B0.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[5].W.B0.BIT[3].OBUF
+ SLICE[3].RAM8x32.WORD[5].W.B0.q_wire[3] SLICE[3].RAM8x32.WORD[5].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[3] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[5].W.B0.BIT[4].LATCH SLICE[0].RAM8x32.Di[4]
+ SLICE[3].RAM8x32.WORD[5].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[5].W.B0.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[5].W.B0.BIT[4].OBUF
+ SLICE[3].RAM8x32.WORD[5].W.B0.q_wire[4] SLICE[3].RAM8x32.WORD[5].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[4] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[5].W.B0.BIT[5].LATCH SLICE[0].RAM8x32.Di[5]
+ SLICE[3].RAM8x32.WORD[5].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[5].W.B0.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[5].W.B0.BIT[5].OBUF
+ SLICE[3].RAM8x32.WORD[5].W.B0.q_wire[5] SLICE[3].RAM8x32.WORD[5].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[5] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[5].W.B0.BIT[6].LATCH SLICE[0].RAM8x32.Di[6]
+ SLICE[3].RAM8x32.WORD[5].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[5].W.B0.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[5].W.B0.BIT[6].OBUF
+ SLICE[3].RAM8x32.WORD[5].W.B0.q_wire[6] SLICE[3].RAM8x32.WORD[5].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[6] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[5].W.B0.BIT[7].LATCH SLICE[0].RAM8x32.Di[7]
+ SLICE[3].RAM8x32.WORD[5].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[5].W.B0.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[5].W.B0.BIT[7].OBUF
+ SLICE[3].RAM8x32.WORD[5].W.B0.q_wire[7] SLICE[3].RAM8x32.WORD[5].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[7] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[5].W.B0.CG SLICE[3].RAM8x32.WORD[5].W.B0.CLK_B
+ SLICE[3].RAM8x32.WORD[5].W.B0.we_wire VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[5].W.B0.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[3].RAM8x32.WORD[5].W.B0.CGAND SLICE[3].RAM8x32.WORD[5].W.B0.SEL
+ SLICE[3].RAM8x32.WORD[0].W.B0.WE VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[5].W.B0.we_wire sky130_fd_sc_hd__and2_1
XSLICE[3].RAM8x32.WORD[5].W.B0.CLKINV SLICE[3].RAM8x32.WORD[5].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[5].W.B0.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[5].W.B0.SELINV SLICE[3].RAM8x32.WORD[5].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[5].W.B0.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[5].W.B1.BIT[0].LATCH SLICE[0].RAM8x32.Di[8]
+ SLICE[3].RAM8x32.WORD[5].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[5].W.B1.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[5].W.B1.BIT[0].OBUF
+ SLICE[3].RAM8x32.WORD[5].W.B1.q_wire[0] SLICE[3].RAM8x32.WORD[5].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[8] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[5].W.B1.BIT[1].LATCH SLICE[0].RAM8x32.Di[9]
+ SLICE[3].RAM8x32.WORD[5].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[5].W.B1.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[5].W.B1.BIT[1].OBUF
+ SLICE[3].RAM8x32.WORD[5].W.B1.q_wire[1] SLICE[3].RAM8x32.WORD[5].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[9] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[5].W.B1.BIT[2].LATCH SLICE[0].RAM8x32.Di[10]
+ SLICE[3].RAM8x32.WORD[5].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[5].W.B1.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[5].W.B1.BIT[2].OBUF
+ SLICE[3].RAM8x32.WORD[5].W.B1.q_wire[2] SLICE[3].RAM8x32.WORD[5].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[10] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[5].W.B1.BIT[3].LATCH SLICE[0].RAM8x32.Di[11]
+ SLICE[3].RAM8x32.WORD[5].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[5].W.B1.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[5].W.B1.BIT[3].OBUF
+ SLICE[3].RAM8x32.WORD[5].W.B1.q_wire[3] SLICE[3].RAM8x32.WORD[5].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[11] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[5].W.B1.BIT[4].LATCH SLICE[0].RAM8x32.Di[12]
+ SLICE[3].RAM8x32.WORD[5].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[5].W.B1.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[5].W.B1.BIT[4].OBUF
+ SLICE[3].RAM8x32.WORD[5].W.B1.q_wire[4] SLICE[3].RAM8x32.WORD[5].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[12] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[5].W.B1.BIT[5].LATCH SLICE[0].RAM8x32.Di[13]
+ SLICE[3].RAM8x32.WORD[5].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[5].W.B1.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[5].W.B1.BIT[5].OBUF
+ SLICE[3].RAM8x32.WORD[5].W.B1.q_wire[5] SLICE[3].RAM8x32.WORD[5].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[13] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[5].W.B1.BIT[6].LATCH SLICE[0].RAM8x32.Di[14]
+ SLICE[3].RAM8x32.WORD[5].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[5].W.B1.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[5].W.B1.BIT[6].OBUF
+ SLICE[3].RAM8x32.WORD[5].W.B1.q_wire[6] SLICE[3].RAM8x32.WORD[5].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[14] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[5].W.B1.BIT[7].LATCH SLICE[0].RAM8x32.Di[15]
+ SLICE[3].RAM8x32.WORD[5].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[5].W.B1.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[5].W.B1.BIT[7].OBUF
+ SLICE[3].RAM8x32.WORD[5].W.B1.q_wire[7] SLICE[3].RAM8x32.WORD[5].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[15] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[5].W.B1.CG SLICE[3].RAM8x32.WORD[5].W.B1.CLK_B
+ SLICE[3].RAM8x32.WORD[5].W.B1.we_wire VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[5].W.B1.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[3].RAM8x32.WORD[5].W.B1.CGAND SLICE[3].RAM8x32.WORD[5].W.B0.SEL
+ SLICE[3].RAM8x32.WORD[0].W.B1.WE VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[5].W.B1.we_wire sky130_fd_sc_hd__and2_1
XSLICE[3].RAM8x32.WORD[5].W.B1.CLKINV SLICE[3].RAM8x32.WORD[5].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[5].W.B1.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[5].W.B1.SELINV SLICE[3].RAM8x32.WORD[5].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[5].W.B1.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[5].W.B2.BIT[0].LATCH SLICE[0].RAM8x32.Di[16]
+ SLICE[3].RAM8x32.WORD[5].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[5].W.B2.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[5].W.B2.BIT[0].OBUF
+ SLICE[3].RAM8x32.WORD[5].W.B2.q_wire[0] SLICE[3].RAM8x32.WORD[5].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[16] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[5].W.B2.BIT[1].LATCH SLICE[0].RAM8x32.Di[17]
+ SLICE[3].RAM8x32.WORD[5].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[5].W.B2.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[5].W.B2.BIT[1].OBUF
+ SLICE[3].RAM8x32.WORD[5].W.B2.q_wire[1] SLICE[3].RAM8x32.WORD[5].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[17] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[5].W.B2.BIT[2].LATCH SLICE[0].RAM8x32.Di[18]
+ SLICE[3].RAM8x32.WORD[5].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[5].W.B2.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[5].W.B2.BIT[2].OBUF
+ SLICE[3].RAM8x32.WORD[5].W.B2.q_wire[2] SLICE[3].RAM8x32.WORD[5].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[18] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[5].W.B2.BIT[3].LATCH SLICE[0].RAM8x32.Di[19]
+ SLICE[3].RAM8x32.WORD[5].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[5].W.B2.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[5].W.B2.BIT[3].OBUF
+ SLICE[3].RAM8x32.WORD[5].W.B2.q_wire[3] SLICE[3].RAM8x32.WORD[5].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[19] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[5].W.B2.BIT[4].LATCH SLICE[0].RAM8x32.Di[20]
+ SLICE[3].RAM8x32.WORD[5].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[5].W.B2.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[5].W.B2.BIT[4].OBUF
+ SLICE[3].RAM8x32.WORD[5].W.B2.q_wire[4] SLICE[3].RAM8x32.WORD[5].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[20] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[5].W.B2.BIT[5].LATCH SLICE[0].RAM8x32.Di[21]
+ SLICE[3].RAM8x32.WORD[5].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[5].W.B2.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[5].W.B2.BIT[5].OBUF
+ SLICE[3].RAM8x32.WORD[5].W.B2.q_wire[5] SLICE[3].RAM8x32.WORD[5].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[21] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[5].W.B2.BIT[6].LATCH SLICE[0].RAM8x32.Di[22]
+ SLICE[3].RAM8x32.WORD[5].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[5].W.B2.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[5].W.B2.BIT[6].OBUF
+ SLICE[3].RAM8x32.WORD[5].W.B2.q_wire[6] SLICE[3].RAM8x32.WORD[5].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[22] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[5].W.B2.BIT[7].LATCH SLICE[0].RAM8x32.Di[23]
+ SLICE[3].RAM8x32.WORD[5].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[5].W.B2.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[5].W.B2.BIT[7].OBUF
+ SLICE[3].RAM8x32.WORD[5].W.B2.q_wire[7] SLICE[3].RAM8x32.WORD[5].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[23] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[5].W.B2.CG SLICE[3].RAM8x32.WORD[5].W.B2.CLK_B
+ SLICE[3].RAM8x32.WORD[5].W.B2.we_wire VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[5].W.B2.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[3].RAM8x32.WORD[5].W.B2.CGAND SLICE[3].RAM8x32.WORD[5].W.B0.SEL
+ SLICE[3].RAM8x32.WORD[0].W.B2.WE VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[5].W.B2.we_wire sky130_fd_sc_hd__and2_1
XSLICE[3].RAM8x32.WORD[5].W.B2.CLKINV SLICE[3].RAM8x32.WORD[5].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[5].W.B2.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[5].W.B2.SELINV SLICE[3].RAM8x32.WORD[5].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[5].W.B2.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[5].W.B3.BIT[0].LATCH SLICE[0].RAM8x32.Di[24]
+ SLICE[3].RAM8x32.WORD[5].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[5].W.B3.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[5].W.B3.BIT[0].OBUF
+ SLICE[3].RAM8x32.WORD[5].W.B3.q_wire[0] SLICE[3].RAM8x32.WORD[5].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[24] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[5].W.B3.BIT[1].LATCH SLICE[0].RAM8x32.Di[25]
+ SLICE[3].RAM8x32.WORD[5].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[5].W.B3.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[5].W.B3.BIT[1].OBUF
+ SLICE[3].RAM8x32.WORD[5].W.B3.q_wire[1] SLICE[3].RAM8x32.WORD[5].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[25] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[5].W.B3.BIT[2].LATCH SLICE[0].RAM8x32.Di[26]
+ SLICE[3].RAM8x32.WORD[5].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[5].W.B3.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[5].W.B3.BIT[2].OBUF
+ SLICE[3].RAM8x32.WORD[5].W.B3.q_wire[2] SLICE[3].RAM8x32.WORD[5].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[26] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[5].W.B3.BIT[3].LATCH SLICE[0].RAM8x32.Di[27]
+ SLICE[3].RAM8x32.WORD[5].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[5].W.B3.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[5].W.B3.BIT[3].OBUF
+ SLICE[3].RAM8x32.WORD[5].W.B3.q_wire[3] SLICE[3].RAM8x32.WORD[5].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[27] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[5].W.B3.BIT[4].LATCH SLICE[0].RAM8x32.Di[28]
+ SLICE[3].RAM8x32.WORD[5].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[5].W.B3.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[5].W.B3.BIT[4].OBUF
+ SLICE[3].RAM8x32.WORD[5].W.B3.q_wire[4] SLICE[3].RAM8x32.WORD[5].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[28] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[5].W.B3.BIT[5].LATCH SLICE[0].RAM8x32.Di[29]
+ SLICE[3].RAM8x32.WORD[5].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[5].W.B3.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[5].W.B3.BIT[5].OBUF
+ SLICE[3].RAM8x32.WORD[5].W.B3.q_wire[5] SLICE[3].RAM8x32.WORD[5].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[29] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[5].W.B3.BIT[6].LATCH SLICE[0].RAM8x32.Di[30]
+ SLICE[3].RAM8x32.WORD[5].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[5].W.B3.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[5].W.B3.BIT[6].OBUF
+ SLICE[3].RAM8x32.WORD[5].W.B3.q_wire[6] SLICE[3].RAM8x32.WORD[5].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[30] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[5].W.B3.BIT[7].LATCH SLICE[0].RAM8x32.Di[31]
+ SLICE[3].RAM8x32.WORD[5].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[5].W.B3.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[5].W.B3.BIT[7].OBUF
+ SLICE[3].RAM8x32.WORD[5].W.B3.q_wire[7] SLICE[3].RAM8x32.WORD[5].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[31] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[5].W.B3.CG SLICE[3].RAM8x32.WORD[5].W.B3.CLK_B
+ SLICE[3].RAM8x32.WORD[5].W.B3.we_wire VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[5].W.B3.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[3].RAM8x32.WORD[5].W.B3.CGAND SLICE[3].RAM8x32.WORD[5].W.B0.SEL
+ SLICE[3].RAM8x32.WORD[0].W.B3.WE VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[5].W.B3.we_wire sky130_fd_sc_hd__and2_1
XSLICE[3].RAM8x32.WORD[5].W.B3.CLKINV SLICE[3].RAM8x32.WORD[5].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[5].W.B3.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[5].W.B3.SELINV SLICE[3].RAM8x32.WORD[5].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[5].W.B3.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[5].W.CLKBUF SLICE[3].RAM8x32.CLK_buf VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[5].W.B0.CLK sky130_fd_sc_hd__clkbuf_1
XSLICE[3].RAM8x32.WORD[5].W.SELBUF SLICE[3].RAM8x32.WORD[5].W.SEL VGND VGND
+ VPWR VPWR SLICE[3].RAM8x32.WORD[5].W.B0.SEL sky130_fd_sc_hd__clkbuf_2
XSLICE[3].RAM8x32.WORD[6].W.B0.BIT[0].LATCH SLICE[0].RAM8x32.Di[0]
+ SLICE[3].RAM8x32.WORD[6].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[6].W.B0.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[6].W.B0.BIT[0].OBUF
+ SLICE[3].RAM8x32.WORD[6].W.B0.q_wire[0] SLICE[3].RAM8x32.WORD[6].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[0] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[6].W.B0.BIT[1].LATCH SLICE[0].RAM8x32.Di[1]
+ SLICE[3].RAM8x32.WORD[6].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[6].W.B0.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[6].W.B0.BIT[1].OBUF
+ SLICE[3].RAM8x32.WORD[6].W.B0.q_wire[1] SLICE[3].RAM8x32.WORD[6].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[1] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[6].W.B0.BIT[2].LATCH SLICE[0].RAM8x32.Di[2]
+ SLICE[3].RAM8x32.WORD[6].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[6].W.B0.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[6].W.B0.BIT[2].OBUF
+ SLICE[3].RAM8x32.WORD[6].W.B0.q_wire[2] SLICE[3].RAM8x32.WORD[6].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[2] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[6].W.B0.BIT[3].LATCH SLICE[0].RAM8x32.Di[3]
+ SLICE[3].RAM8x32.WORD[6].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[6].W.B0.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[6].W.B0.BIT[3].OBUF
+ SLICE[3].RAM8x32.WORD[6].W.B0.q_wire[3] SLICE[3].RAM8x32.WORD[6].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[3] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[6].W.B0.BIT[4].LATCH SLICE[0].RAM8x32.Di[4]
+ SLICE[3].RAM8x32.WORD[6].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[6].W.B0.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[6].W.B0.BIT[4].OBUF
+ SLICE[3].RAM8x32.WORD[6].W.B0.q_wire[4] SLICE[3].RAM8x32.WORD[6].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[4] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[6].W.B0.BIT[5].LATCH SLICE[0].RAM8x32.Di[5]
+ SLICE[3].RAM8x32.WORD[6].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[6].W.B0.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[6].W.B0.BIT[5].OBUF
+ SLICE[3].RAM8x32.WORD[6].W.B0.q_wire[5] SLICE[3].RAM8x32.WORD[6].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[5] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[6].W.B0.BIT[6].LATCH SLICE[0].RAM8x32.Di[6]
+ SLICE[3].RAM8x32.WORD[6].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[6].W.B0.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[6].W.B0.BIT[6].OBUF
+ SLICE[3].RAM8x32.WORD[6].W.B0.q_wire[6] SLICE[3].RAM8x32.WORD[6].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[6] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[6].W.B0.BIT[7].LATCH SLICE[0].RAM8x32.Di[7]
+ SLICE[3].RAM8x32.WORD[6].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[6].W.B0.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[6].W.B0.BIT[7].OBUF
+ SLICE[3].RAM8x32.WORD[6].W.B0.q_wire[7] SLICE[3].RAM8x32.WORD[6].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[7] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[6].W.B0.CG SLICE[3].RAM8x32.WORD[6].W.B0.CLK_B
+ SLICE[3].RAM8x32.WORD[6].W.B0.we_wire VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[6].W.B0.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[3].RAM8x32.WORD[6].W.B0.CGAND SLICE[3].RAM8x32.WORD[6].W.B0.SEL
+ SLICE[3].RAM8x32.WORD[0].W.B0.WE VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[6].W.B0.we_wire sky130_fd_sc_hd__and2_1
XSLICE[3].RAM8x32.WORD[6].W.B0.CLKINV SLICE[3].RAM8x32.WORD[6].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[6].W.B0.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[6].W.B0.SELINV SLICE[3].RAM8x32.WORD[6].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[6].W.B0.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[6].W.B1.BIT[0].LATCH SLICE[0].RAM8x32.Di[8]
+ SLICE[3].RAM8x32.WORD[6].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[6].W.B1.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[6].W.B1.BIT[0].OBUF
+ SLICE[3].RAM8x32.WORD[6].W.B1.q_wire[0] SLICE[3].RAM8x32.WORD[6].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[8] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[6].W.B1.BIT[1].LATCH SLICE[0].RAM8x32.Di[9]
+ SLICE[3].RAM8x32.WORD[6].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[6].W.B1.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[6].W.B1.BIT[1].OBUF
+ SLICE[3].RAM8x32.WORD[6].W.B1.q_wire[1] SLICE[3].RAM8x32.WORD[6].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[9] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[6].W.B1.BIT[2].LATCH SLICE[0].RAM8x32.Di[10]
+ SLICE[3].RAM8x32.WORD[6].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[6].W.B1.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[6].W.B1.BIT[2].OBUF
+ SLICE[3].RAM8x32.WORD[6].W.B1.q_wire[2] SLICE[3].RAM8x32.WORD[6].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[10] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[6].W.B1.BIT[3].LATCH SLICE[0].RAM8x32.Di[11]
+ SLICE[3].RAM8x32.WORD[6].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[6].W.B1.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[6].W.B1.BIT[3].OBUF
+ SLICE[3].RAM8x32.WORD[6].W.B1.q_wire[3] SLICE[3].RAM8x32.WORD[6].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[11] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[6].W.B1.BIT[4].LATCH SLICE[0].RAM8x32.Di[12]
+ SLICE[3].RAM8x32.WORD[6].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[6].W.B1.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[6].W.B1.BIT[4].OBUF
+ SLICE[3].RAM8x32.WORD[6].W.B1.q_wire[4] SLICE[3].RAM8x32.WORD[6].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[12] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[6].W.B1.BIT[5].LATCH SLICE[0].RAM8x32.Di[13]
+ SLICE[3].RAM8x32.WORD[6].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[6].W.B1.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[6].W.B1.BIT[5].OBUF
+ SLICE[3].RAM8x32.WORD[6].W.B1.q_wire[5] SLICE[3].RAM8x32.WORD[6].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[13] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[6].W.B1.BIT[6].LATCH SLICE[0].RAM8x32.Di[14]
+ SLICE[3].RAM8x32.WORD[6].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[6].W.B1.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[6].W.B1.BIT[6].OBUF
+ SLICE[3].RAM8x32.WORD[6].W.B1.q_wire[6] SLICE[3].RAM8x32.WORD[6].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[14] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[6].W.B1.BIT[7].LATCH SLICE[0].RAM8x32.Di[15]
+ SLICE[3].RAM8x32.WORD[6].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[6].W.B1.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[6].W.B1.BIT[7].OBUF
+ SLICE[3].RAM8x32.WORD[6].W.B1.q_wire[7] SLICE[3].RAM8x32.WORD[6].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[15] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[6].W.B1.CG SLICE[3].RAM8x32.WORD[6].W.B1.CLK_B
+ SLICE[3].RAM8x32.WORD[6].W.B1.we_wire VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[6].W.B1.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[3].RAM8x32.WORD[6].W.B1.CGAND SLICE[3].RAM8x32.WORD[6].W.B0.SEL
+ SLICE[3].RAM8x32.WORD[0].W.B1.WE VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[6].W.B1.we_wire sky130_fd_sc_hd__and2_1
XSLICE[3].RAM8x32.WORD[6].W.B1.CLKINV SLICE[3].RAM8x32.WORD[6].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[6].W.B1.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[6].W.B1.SELINV SLICE[3].RAM8x32.WORD[6].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[6].W.B1.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[6].W.B2.BIT[0].LATCH SLICE[0].RAM8x32.Di[16]
+ SLICE[3].RAM8x32.WORD[6].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[6].W.B2.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[6].W.B2.BIT[0].OBUF
+ SLICE[3].RAM8x32.WORD[6].W.B2.q_wire[0] SLICE[3].RAM8x32.WORD[6].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[16] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[6].W.B2.BIT[1].LATCH SLICE[0].RAM8x32.Di[17]
+ SLICE[3].RAM8x32.WORD[6].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[6].W.B2.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[6].W.B2.BIT[1].OBUF
+ SLICE[3].RAM8x32.WORD[6].W.B2.q_wire[1] SLICE[3].RAM8x32.WORD[6].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[17] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[6].W.B2.BIT[2].LATCH SLICE[0].RAM8x32.Di[18]
+ SLICE[3].RAM8x32.WORD[6].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[6].W.B2.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[6].W.B2.BIT[2].OBUF
+ SLICE[3].RAM8x32.WORD[6].W.B2.q_wire[2] SLICE[3].RAM8x32.WORD[6].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[18] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[6].W.B2.BIT[3].LATCH SLICE[0].RAM8x32.Di[19]
+ SLICE[3].RAM8x32.WORD[6].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[6].W.B2.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[6].W.B2.BIT[3].OBUF
+ SLICE[3].RAM8x32.WORD[6].W.B2.q_wire[3] SLICE[3].RAM8x32.WORD[6].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[19] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[6].W.B2.BIT[4].LATCH SLICE[0].RAM8x32.Di[20]
+ SLICE[3].RAM8x32.WORD[6].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[6].W.B2.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[6].W.B2.BIT[4].OBUF
+ SLICE[3].RAM8x32.WORD[6].W.B2.q_wire[4] SLICE[3].RAM8x32.WORD[6].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[20] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[6].W.B2.BIT[5].LATCH SLICE[0].RAM8x32.Di[21]
+ SLICE[3].RAM8x32.WORD[6].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[6].W.B2.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[6].W.B2.BIT[5].OBUF
+ SLICE[3].RAM8x32.WORD[6].W.B2.q_wire[5] SLICE[3].RAM8x32.WORD[6].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[21] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[6].W.B2.BIT[6].LATCH SLICE[0].RAM8x32.Di[22]
+ SLICE[3].RAM8x32.WORD[6].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[6].W.B2.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[6].W.B2.BIT[6].OBUF
+ SLICE[3].RAM8x32.WORD[6].W.B2.q_wire[6] SLICE[3].RAM8x32.WORD[6].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[22] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[6].W.B2.BIT[7].LATCH SLICE[0].RAM8x32.Di[23]
+ SLICE[3].RAM8x32.WORD[6].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[6].W.B2.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[6].W.B2.BIT[7].OBUF
+ SLICE[3].RAM8x32.WORD[6].W.B2.q_wire[7] SLICE[3].RAM8x32.WORD[6].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[23] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[6].W.B2.CG SLICE[3].RAM8x32.WORD[6].W.B2.CLK_B
+ SLICE[3].RAM8x32.WORD[6].W.B2.we_wire VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[6].W.B2.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[3].RAM8x32.WORD[6].W.B2.CGAND SLICE[3].RAM8x32.WORD[6].W.B0.SEL
+ SLICE[3].RAM8x32.WORD[0].W.B2.WE VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[6].W.B2.we_wire sky130_fd_sc_hd__and2_1
XSLICE[3].RAM8x32.WORD[6].W.B2.CLKINV SLICE[3].RAM8x32.WORD[6].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[6].W.B2.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[6].W.B2.SELINV SLICE[3].RAM8x32.WORD[6].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[6].W.B2.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[6].W.B3.BIT[0].LATCH SLICE[0].RAM8x32.Di[24]
+ SLICE[3].RAM8x32.WORD[6].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[6].W.B3.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[6].W.B3.BIT[0].OBUF
+ SLICE[3].RAM8x32.WORD[6].W.B3.q_wire[0] SLICE[3].RAM8x32.WORD[6].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[24] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[6].W.B3.BIT[1].LATCH SLICE[0].RAM8x32.Di[25]
+ SLICE[3].RAM8x32.WORD[6].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[6].W.B3.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[6].W.B3.BIT[1].OBUF
+ SLICE[3].RAM8x32.WORD[6].W.B3.q_wire[1] SLICE[3].RAM8x32.WORD[6].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[25] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[6].W.B3.BIT[2].LATCH SLICE[0].RAM8x32.Di[26]
+ SLICE[3].RAM8x32.WORD[6].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[6].W.B3.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[6].W.B3.BIT[2].OBUF
+ SLICE[3].RAM8x32.WORD[6].W.B3.q_wire[2] SLICE[3].RAM8x32.WORD[6].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[26] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[6].W.B3.BIT[3].LATCH SLICE[0].RAM8x32.Di[27]
+ SLICE[3].RAM8x32.WORD[6].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[6].W.B3.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[6].W.B3.BIT[3].OBUF
+ SLICE[3].RAM8x32.WORD[6].W.B3.q_wire[3] SLICE[3].RAM8x32.WORD[6].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[27] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[6].W.B3.BIT[4].LATCH SLICE[0].RAM8x32.Di[28]
+ SLICE[3].RAM8x32.WORD[6].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[6].W.B3.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[6].W.B3.BIT[4].OBUF
+ SLICE[3].RAM8x32.WORD[6].W.B3.q_wire[4] SLICE[3].RAM8x32.WORD[6].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[28] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[6].W.B3.BIT[5].LATCH SLICE[0].RAM8x32.Di[29]
+ SLICE[3].RAM8x32.WORD[6].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[6].W.B3.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[6].W.B3.BIT[5].OBUF
+ SLICE[3].RAM8x32.WORD[6].W.B3.q_wire[5] SLICE[3].RAM8x32.WORD[6].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[29] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[6].W.B3.BIT[6].LATCH SLICE[0].RAM8x32.Di[30]
+ SLICE[3].RAM8x32.WORD[6].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[6].W.B3.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[6].W.B3.BIT[6].OBUF
+ SLICE[3].RAM8x32.WORD[6].W.B3.q_wire[6] SLICE[3].RAM8x32.WORD[6].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[30] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[6].W.B3.BIT[7].LATCH SLICE[0].RAM8x32.Di[31]
+ SLICE[3].RAM8x32.WORD[6].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[6].W.B3.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[6].W.B3.BIT[7].OBUF
+ SLICE[3].RAM8x32.WORD[6].W.B3.q_wire[7] SLICE[3].RAM8x32.WORD[6].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[31] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[6].W.B3.CG SLICE[3].RAM8x32.WORD[6].W.B3.CLK_B
+ SLICE[3].RAM8x32.WORD[6].W.B3.we_wire VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[6].W.B3.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[3].RAM8x32.WORD[6].W.B3.CGAND SLICE[3].RAM8x32.WORD[6].W.B0.SEL
+ SLICE[3].RAM8x32.WORD[0].W.B3.WE VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[6].W.B3.we_wire sky130_fd_sc_hd__and2_1
XSLICE[3].RAM8x32.WORD[6].W.B3.CLKINV SLICE[3].RAM8x32.WORD[6].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[6].W.B3.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[6].W.B3.SELINV SLICE[3].RAM8x32.WORD[6].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[6].W.B3.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[6].W.CLKBUF SLICE[3].RAM8x32.CLK_buf VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[6].W.B0.CLK sky130_fd_sc_hd__clkbuf_1
XSLICE[3].RAM8x32.WORD[6].W.SELBUF SLICE[3].RAM8x32.WORD[6].W.SEL VGND VGND
+ VPWR VPWR SLICE[3].RAM8x32.WORD[6].W.B0.SEL sky130_fd_sc_hd__clkbuf_2
XSLICE[3].RAM8x32.WORD[7].W.B0.BIT[0].LATCH SLICE[0].RAM8x32.Di[0]
+ SLICE[3].RAM8x32.WORD[7].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[7].W.B0.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[7].W.B0.BIT[0].OBUF
+ SLICE[3].RAM8x32.WORD[7].W.B0.q_wire[0] SLICE[3].RAM8x32.WORD[7].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[0] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[7].W.B0.BIT[1].LATCH SLICE[0].RAM8x32.Di[1]
+ SLICE[3].RAM8x32.WORD[7].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[7].W.B0.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[7].W.B0.BIT[1].OBUF
+ SLICE[3].RAM8x32.WORD[7].W.B0.q_wire[1] SLICE[3].RAM8x32.WORD[7].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[1] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[7].W.B0.BIT[2].LATCH SLICE[0].RAM8x32.Di[2]
+ SLICE[3].RAM8x32.WORD[7].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[7].W.B0.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[7].W.B0.BIT[2].OBUF
+ SLICE[3].RAM8x32.WORD[7].W.B0.q_wire[2] SLICE[3].RAM8x32.WORD[7].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[2] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[7].W.B0.BIT[3].LATCH SLICE[0].RAM8x32.Di[3]
+ SLICE[3].RAM8x32.WORD[7].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[7].W.B0.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[7].W.B0.BIT[3].OBUF
+ SLICE[3].RAM8x32.WORD[7].W.B0.q_wire[3] SLICE[3].RAM8x32.WORD[7].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[3] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[7].W.B0.BIT[4].LATCH SLICE[0].RAM8x32.Di[4]
+ SLICE[3].RAM8x32.WORD[7].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[7].W.B0.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[7].W.B0.BIT[4].OBUF
+ SLICE[3].RAM8x32.WORD[7].W.B0.q_wire[4] SLICE[3].RAM8x32.WORD[7].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[4] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[7].W.B0.BIT[5].LATCH SLICE[0].RAM8x32.Di[5]
+ SLICE[3].RAM8x32.WORD[7].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[7].W.B0.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[7].W.B0.BIT[5].OBUF
+ SLICE[3].RAM8x32.WORD[7].W.B0.q_wire[5] SLICE[3].RAM8x32.WORD[7].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[5] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[7].W.B0.BIT[6].LATCH SLICE[0].RAM8x32.Di[6]
+ SLICE[3].RAM8x32.WORD[7].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[7].W.B0.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[7].W.B0.BIT[6].OBUF
+ SLICE[3].RAM8x32.WORD[7].W.B0.q_wire[6] SLICE[3].RAM8x32.WORD[7].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[6] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[7].W.B0.BIT[7].LATCH SLICE[0].RAM8x32.Di[7]
+ SLICE[3].RAM8x32.WORD[7].W.B0.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[7].W.B0.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[7].W.B0.BIT[7].OBUF
+ SLICE[3].RAM8x32.WORD[7].W.B0.q_wire[7] SLICE[3].RAM8x32.WORD[7].W.B0.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[7] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[7].W.B0.CG SLICE[3].RAM8x32.WORD[7].W.B0.CLK_B
+ SLICE[3].RAM8x32.WORD[7].W.B0.we_wire VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[7].W.B0.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[3].RAM8x32.WORD[7].W.B0.CGAND SLICE[3].RAM8x32.WORD[7].W.B0.SEL
+ SLICE[3].RAM8x32.WORD[0].W.B0.WE VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[7].W.B0.we_wire sky130_fd_sc_hd__and2_1
XSLICE[3].RAM8x32.WORD[7].W.B0.CLKINV SLICE[3].RAM8x32.WORD[7].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[7].W.B0.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[7].W.B0.SELINV SLICE[3].RAM8x32.WORD[7].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[7].W.B0.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[7].W.B1.BIT[0].LATCH SLICE[0].RAM8x32.Di[8]
+ SLICE[3].RAM8x32.WORD[7].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[7].W.B1.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[7].W.B1.BIT[0].OBUF
+ SLICE[3].RAM8x32.WORD[7].W.B1.q_wire[0] SLICE[3].RAM8x32.WORD[7].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[8] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[7].W.B1.BIT[1].LATCH SLICE[0].RAM8x32.Di[9]
+ SLICE[3].RAM8x32.WORD[7].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[7].W.B1.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[7].W.B1.BIT[1].OBUF
+ SLICE[3].RAM8x32.WORD[7].W.B1.q_wire[1] SLICE[3].RAM8x32.WORD[7].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[9] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[7].W.B1.BIT[2].LATCH SLICE[0].RAM8x32.Di[10]
+ SLICE[3].RAM8x32.WORD[7].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[7].W.B1.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[7].W.B1.BIT[2].OBUF
+ SLICE[3].RAM8x32.WORD[7].W.B1.q_wire[2] SLICE[3].RAM8x32.WORD[7].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[10] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[7].W.B1.BIT[3].LATCH SLICE[0].RAM8x32.Di[11]
+ SLICE[3].RAM8x32.WORD[7].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[7].W.B1.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[7].W.B1.BIT[3].OBUF
+ SLICE[3].RAM8x32.WORD[7].W.B1.q_wire[3] SLICE[3].RAM8x32.WORD[7].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[11] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[7].W.B1.BIT[4].LATCH SLICE[0].RAM8x32.Di[12]
+ SLICE[3].RAM8x32.WORD[7].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[7].W.B1.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[7].W.B1.BIT[4].OBUF
+ SLICE[3].RAM8x32.WORD[7].W.B1.q_wire[4] SLICE[3].RAM8x32.WORD[7].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[12] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[7].W.B1.BIT[5].LATCH SLICE[0].RAM8x32.Di[13]
+ SLICE[3].RAM8x32.WORD[7].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[7].W.B1.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[7].W.B1.BIT[5].OBUF
+ SLICE[3].RAM8x32.WORD[7].W.B1.q_wire[5] SLICE[3].RAM8x32.WORD[7].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[13] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[7].W.B1.BIT[6].LATCH SLICE[0].RAM8x32.Di[14]
+ SLICE[3].RAM8x32.WORD[7].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[7].W.B1.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[7].W.B1.BIT[6].OBUF
+ SLICE[3].RAM8x32.WORD[7].W.B1.q_wire[6] SLICE[3].RAM8x32.WORD[7].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[14] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[7].W.B1.BIT[7].LATCH SLICE[0].RAM8x32.Di[15]
+ SLICE[3].RAM8x32.WORD[7].W.B1.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[7].W.B1.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[7].W.B1.BIT[7].OBUF
+ SLICE[3].RAM8x32.WORD[7].W.B1.q_wire[7] SLICE[3].RAM8x32.WORD[7].W.B1.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[15] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[7].W.B1.CG SLICE[3].RAM8x32.WORD[7].W.B1.CLK_B
+ SLICE[3].RAM8x32.WORD[7].W.B1.we_wire VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[7].W.B1.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[3].RAM8x32.WORD[7].W.B1.CGAND SLICE[3].RAM8x32.WORD[7].W.B0.SEL
+ SLICE[3].RAM8x32.WORD[0].W.B1.WE VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[7].W.B1.we_wire sky130_fd_sc_hd__and2_1
XSLICE[3].RAM8x32.WORD[7].W.B1.CLKINV SLICE[3].RAM8x32.WORD[7].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[7].W.B1.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[7].W.B1.SELINV SLICE[3].RAM8x32.WORD[7].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[7].W.B1.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[7].W.B2.BIT[0].LATCH SLICE[0].RAM8x32.Di[16]
+ SLICE[3].RAM8x32.WORD[7].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[7].W.B2.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[7].W.B2.BIT[0].OBUF
+ SLICE[3].RAM8x32.WORD[7].W.B2.q_wire[0] SLICE[3].RAM8x32.WORD[7].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[16] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[7].W.B2.BIT[1].LATCH SLICE[0].RAM8x32.Di[17]
+ SLICE[3].RAM8x32.WORD[7].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[7].W.B2.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[7].W.B2.BIT[1].OBUF
+ SLICE[3].RAM8x32.WORD[7].W.B2.q_wire[1] SLICE[3].RAM8x32.WORD[7].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[17] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[7].W.B2.BIT[2].LATCH SLICE[0].RAM8x32.Di[18]
+ SLICE[3].RAM8x32.WORD[7].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[7].W.B2.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[7].W.B2.BIT[2].OBUF
+ SLICE[3].RAM8x32.WORD[7].W.B2.q_wire[2] SLICE[3].RAM8x32.WORD[7].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[18] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[7].W.B2.BIT[3].LATCH SLICE[0].RAM8x32.Di[19]
+ SLICE[3].RAM8x32.WORD[7].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[7].W.B2.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[7].W.B2.BIT[3].OBUF
+ SLICE[3].RAM8x32.WORD[7].W.B2.q_wire[3] SLICE[3].RAM8x32.WORD[7].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[19] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[7].W.B2.BIT[4].LATCH SLICE[0].RAM8x32.Di[20]
+ SLICE[3].RAM8x32.WORD[7].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[7].W.B2.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[7].W.B2.BIT[4].OBUF
+ SLICE[3].RAM8x32.WORD[7].W.B2.q_wire[4] SLICE[3].RAM8x32.WORD[7].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[20] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[7].W.B2.BIT[5].LATCH SLICE[0].RAM8x32.Di[21]
+ SLICE[3].RAM8x32.WORD[7].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[7].W.B2.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[7].W.B2.BIT[5].OBUF
+ SLICE[3].RAM8x32.WORD[7].W.B2.q_wire[5] SLICE[3].RAM8x32.WORD[7].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[21] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[7].W.B2.BIT[6].LATCH SLICE[0].RAM8x32.Di[22]
+ SLICE[3].RAM8x32.WORD[7].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[7].W.B2.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[7].W.B2.BIT[6].OBUF
+ SLICE[3].RAM8x32.WORD[7].W.B2.q_wire[6] SLICE[3].RAM8x32.WORD[7].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[22] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[7].W.B2.BIT[7].LATCH SLICE[0].RAM8x32.Di[23]
+ SLICE[3].RAM8x32.WORD[7].W.B2.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[7].W.B2.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[7].W.B2.BIT[7].OBUF
+ SLICE[3].RAM8x32.WORD[7].W.B2.q_wire[7] SLICE[3].RAM8x32.WORD[7].W.B2.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[23] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[7].W.B2.CG SLICE[3].RAM8x32.WORD[7].W.B2.CLK_B
+ SLICE[3].RAM8x32.WORD[7].W.B2.we_wire VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[7].W.B2.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[3].RAM8x32.WORD[7].W.B2.CGAND SLICE[3].RAM8x32.WORD[7].W.B0.SEL
+ SLICE[3].RAM8x32.WORD[0].W.B2.WE VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[7].W.B2.we_wire sky130_fd_sc_hd__and2_1
XSLICE[3].RAM8x32.WORD[7].W.B2.CLKINV SLICE[3].RAM8x32.WORD[7].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[7].W.B2.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[7].W.B2.SELINV SLICE[3].RAM8x32.WORD[7].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[7].W.B2.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[7].W.B3.BIT[0].LATCH SLICE[0].RAM8x32.Di[24]
+ SLICE[3].RAM8x32.WORD[7].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[7].W.B3.q_wire[0] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[7].W.B3.BIT[0].OBUF
+ SLICE[3].RAM8x32.WORD[7].W.B3.q_wire[0] SLICE[3].RAM8x32.WORD[7].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[24] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[7].W.B3.BIT[1].LATCH SLICE[0].RAM8x32.Di[25]
+ SLICE[3].RAM8x32.WORD[7].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[7].W.B3.q_wire[1] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[7].W.B3.BIT[1].OBUF
+ SLICE[3].RAM8x32.WORD[7].W.B3.q_wire[1] SLICE[3].RAM8x32.WORD[7].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[25] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[7].W.B3.BIT[2].LATCH SLICE[0].RAM8x32.Di[26]
+ SLICE[3].RAM8x32.WORD[7].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[7].W.B3.q_wire[2] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[7].W.B3.BIT[2].OBUF
+ SLICE[3].RAM8x32.WORD[7].W.B3.q_wire[2] SLICE[3].RAM8x32.WORD[7].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[26] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[7].W.B3.BIT[3].LATCH SLICE[0].RAM8x32.Di[27]
+ SLICE[3].RAM8x32.WORD[7].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[7].W.B3.q_wire[3] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[7].W.B3.BIT[3].OBUF
+ SLICE[3].RAM8x32.WORD[7].W.B3.q_wire[3] SLICE[3].RAM8x32.WORD[7].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[27] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[7].W.B3.BIT[4].LATCH SLICE[0].RAM8x32.Di[28]
+ SLICE[3].RAM8x32.WORD[7].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[7].W.B3.q_wire[4] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[7].W.B3.BIT[4].OBUF
+ SLICE[3].RAM8x32.WORD[7].W.B3.q_wire[4] SLICE[3].RAM8x32.WORD[7].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[28] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[7].W.B3.BIT[5].LATCH SLICE[0].RAM8x32.Di[29]
+ SLICE[3].RAM8x32.WORD[7].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[7].W.B3.q_wire[5] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[7].W.B3.BIT[5].OBUF
+ SLICE[3].RAM8x32.WORD[7].W.B3.q_wire[5] SLICE[3].RAM8x32.WORD[7].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[29] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[7].W.B3.BIT[6].LATCH SLICE[0].RAM8x32.Di[30]
+ SLICE[3].RAM8x32.WORD[7].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[7].W.B3.q_wire[6] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[7].W.B3.BIT[6].OBUF
+ SLICE[3].RAM8x32.WORD[7].W.B3.q_wire[6] SLICE[3].RAM8x32.WORD[7].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[30] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[7].W.B3.BIT[7].LATCH SLICE[0].RAM8x32.Di[31]
+ SLICE[3].RAM8x32.WORD[7].W.B3.GCLK VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[7].W.B3.q_wire[7] sky130_fd_sc_hd__dlxtp_1
XSLICE[3].RAM8x32.WORD[7].W.B3.BIT[7].OBUF
+ SLICE[3].RAM8x32.WORD[7].W.B3.q_wire[7] SLICE[3].RAM8x32.WORD[7].W.B3.SEL_B
+ VGND VGND VPWR VPWR SLICE[0].RAM8x32.Do[31] sky130_fd_sc_hd__ebufn_2
XSLICE[3].RAM8x32.WORD[7].W.B3.CG SLICE[3].RAM8x32.WORD[7].W.B3.CLK_B
+ SLICE[3].RAM8x32.WORD[7].W.B3.we_wire VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[7].W.B3.GCLK sky130_fd_sc_hd__dlclkp_1
XSLICE[3].RAM8x32.WORD[7].W.B3.CGAND SLICE[3].RAM8x32.WORD[7].W.B0.SEL
+ SLICE[3].RAM8x32.WORD[0].W.B3.WE VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[7].W.B3.we_wire sky130_fd_sc_hd__and2_1
XSLICE[3].RAM8x32.WORD[7].W.B3.CLKINV SLICE[3].RAM8x32.WORD[7].W.B0.CLK VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[7].W.B3.CLK_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[7].W.B3.SELINV SLICE[3].RAM8x32.WORD[7].W.B0.SEL VGND
+ VGND VPWR VPWR SLICE[3].RAM8x32.WORD[7].W.B3.SEL_B sky130_fd_sc_hd__inv_1
XSLICE[3].RAM8x32.WORD[7].W.CLKBUF SLICE[3].RAM8x32.CLK_buf VGND VGND VPWR VPWR
+ SLICE[3].RAM8x32.WORD[7].W.B0.CLK sky130_fd_sc_hd__clkbuf_1
XSLICE[3].RAM8x32.WORD[7].W.SELBUF SLICE[3].RAM8x32.WORD[7].W.SEL VGND VGND
+ VPWR VPWR SLICE[3].RAM8x32.WORD[7].W.B0.SEL sky130_fd_sc_hd__clkbuf_2
XTIE[0] VGND VGND VPWR VPWR 1000 lo[0] sky130_fd_sc_hd__conb_1
XTIE[1] VGND VGND VPWR VPWR 1001 lo[1] sky130_fd_sc_hd__conb_1
XTIE[2] VGND VGND VPWR VPWR 1002 lo[2] sky130_fd_sc_hd__conb_1
XTIE[3] VGND VGND VPWR VPWR 1003 lo[3] sky130_fd_sc_hd__conb_1
XWEBUF[0] WE[0] VGND VGND VPWR VPWR SLICE[0].RAM8x32.WE[0]
+ sky130_fd_sc_hd__clkbuf_2
XWEBUF[1] WE[1] VGND VGND VPWR VPWR SLICE[0].RAM8x32.WE[1]
+ sky130_fd_sc_hd__clkbuf_2
XWEBUF[2] WE[2] VGND VGND VPWR VPWR SLICE[0].RAM8x32.WE[2]
+ sky130_fd_sc_hd__clkbuf_2
XWEBUF[3] WE[3] VGND VGND VPWR VPWR SLICE[0].RAM8x32.WE[3]
+ sky130_fd_sc_hd__clkbuf_2
Xfill_0_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_0_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_0_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_0_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_0_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_0_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfill_0_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfill_0_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfill_0_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfill_0_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_0_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_0_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_0_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_0_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_0_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_0_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_0_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_10_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfill_10_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfill_10_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_10_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfill_11_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfill_11_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_11_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfill_12_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfill_12_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfill_12_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_12_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfill_13_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfill_13_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_13_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfill_14_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfill_14_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfill_14_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfill_14_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfill_14_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_14_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfill_15_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfill_15_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfill_15_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfill_15_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_15_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfill_16_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfill_16_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfill_16_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfill_16_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_16_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfill_17_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_17_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfill_18_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfill_18_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfill_18_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_18_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfill_19_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfill_19_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_19_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfill_19_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfill_1_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_1_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfill_20_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfill_20_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfill_20_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_20_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfill_20_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfill_21_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfill_21_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_21_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfill_21_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfill_22_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfill_22_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfill_22_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfill_22_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfill_22_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_22_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfill_22_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfill_23_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfill_23_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfill_23_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfill_23_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_23_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfill_23_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfill_24_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfill_24_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfill_24_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfill_24_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_24_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfill_24_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfill_25_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_25_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfill_25_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfill_26_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfill_26_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfill_26_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_26_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfill_26_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfill_27_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfill_27_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_27_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfill_27_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfill_28_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfill_28_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfill_28_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_28_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfill_28_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfill_29_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfill_29_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_29_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfill_29_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfill_2_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfill_2_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfill_2_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_2_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfill_30_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfill_30_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfill_30_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfill_30_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfill_30_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_30_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfill_30_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfill_31_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfill_31_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfill_31_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfill_31_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_31_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfill_31_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfill_32_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfill_32_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfill_32_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfill_32_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_32_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfill_32_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfill_33_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_33_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_33_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_33_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_33_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_33_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_33_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_33_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_33_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_33_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_33_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_33_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_33_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_33_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_33_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_33_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_33_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_33_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_33_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_33_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_33_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_33_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_33_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_33_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_33_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_33_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_33_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_33_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_33_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_33_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_33_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_33_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_33_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_33_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_33_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_33_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_33_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_33_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_33_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfill_33_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfill_33_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_33_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_33_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_33_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_33_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_34_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_34_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_34_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_34_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_34_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_34_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_34_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_34_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_34_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_34_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_34_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_34_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_34_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_34_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_34_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_34_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_34_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_34_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_34_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfill_34_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfill_34_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfill_34_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfill_34_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_34_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_34_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_34_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_34_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_34_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_34_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_3_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfill_3_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_3_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfill_4_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfill_4_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfill_4_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_4_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfill_5_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfill_5_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_5_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfill_6_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfill_6_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfill_6_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfill_6_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfill_6_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfill_7_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfill_7_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfill_7_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfill_7_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_8_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfill_8_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfill_8_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfill_8_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_9_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xfill_9_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xtap_0_0 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_0_1 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_0_10 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_0_11 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_0_12 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_0_13 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_0_14 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_0_15 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_0_16 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_0_17 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_0_18 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_0_19 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_0_2 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_0_20 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_0_21 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_0_22 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_0_23 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_0_24 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_0_25 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_0_26 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_0_27 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_0_28 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_0_29 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_0_3 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_0_30 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_0_31 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_0_32 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_0_33 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_0_34 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_0_35 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_0_36 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_0_37 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_0_4 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_0_5 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_0_6 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_0_7 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_0_8 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_0_9 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_10_0 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_10_1 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_10_10 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_10_11 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_10_12 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_10_13 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_10_14 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_10_15 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_10_16 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_10_17 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_10_18 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_10_19 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_10_2 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_10_20 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_10_21 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_10_22 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_10_23 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_10_24 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_10_25 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_10_26 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_10_27 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_10_28 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_10_29 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_10_3 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_10_30 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_10_31 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_10_32 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_10_33 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_10_34 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_10_35 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_10_36 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_10_4 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_10_5 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_10_6 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_10_7 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_10_8 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_10_9 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_11_0 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_11_1 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_11_10 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_11_11 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_11_12 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_11_13 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_11_14 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_11_15 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_11_16 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_11_17 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_11_18 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_11_19 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_11_2 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_11_20 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_11_21 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_11_22 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_11_23 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_11_24 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_11_25 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_11_26 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_11_27 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_11_28 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_11_29 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_11_3 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_11_30 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_11_31 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_11_32 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_11_33 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_11_34 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_11_35 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_11_36 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_11_37 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_11_4 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_11_5 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_11_6 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_11_7 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_11_8 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_11_9 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_12_0 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_12_1 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_12_10 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_12_11 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_12_12 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_12_13 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_12_14 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_12_15 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_12_16 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_12_17 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_12_18 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_12_19 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_12_2 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_12_20 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_12_21 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_12_22 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_12_23 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_12_24 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_12_25 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_12_26 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_12_27 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_12_28 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_12_29 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_12_3 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_12_30 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_12_31 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_12_32 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_12_33 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_12_34 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_12_35 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_12_36 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_12_4 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_12_5 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_12_6 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_12_7 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_12_8 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_12_9 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_13_0 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_13_1 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_13_10 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_13_11 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_13_12 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_13_13 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_13_14 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_13_15 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_13_16 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_13_17 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_13_18 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_13_19 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_13_2 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_13_20 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_13_21 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_13_22 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_13_23 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_13_24 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_13_25 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_13_26 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_13_27 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_13_28 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_13_29 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_13_3 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_13_30 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_13_31 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_13_32 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_13_33 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_13_34 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_13_35 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_13_36 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_13_37 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_13_4 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_13_5 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_13_6 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_13_7 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_13_8 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_13_9 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_14_0 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_14_1 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_14_10 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_14_11 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_14_12 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_14_13 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_14_14 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_14_15 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_14_16 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_14_17 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_14_18 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_14_19 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_14_2 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_14_20 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_14_21 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_14_22 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_14_23 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_14_24 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_14_25 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_14_26 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_14_27 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_14_28 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_14_29 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_14_3 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_14_30 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_14_31 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_14_32 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_14_33 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_14_34 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_14_35 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_14_36 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_14_4 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_14_5 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_14_6 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_14_7 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_14_8 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_14_9 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_15_0 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_15_1 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_15_10 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_15_11 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_15_12 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_15_13 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_15_14 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_15_15 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_15_16 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_15_17 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_15_18 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_15_19 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_15_2 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_15_20 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_15_21 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_15_22 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_15_23 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_15_24 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_15_25 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_15_26 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_15_27 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_15_28 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_15_29 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_15_3 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_15_30 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_15_31 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_15_32 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_15_33 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_15_34 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_15_35 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_15_36 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_15_37 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_15_4 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_15_5 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_15_6 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_15_7 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_15_8 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_15_9 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_16_0 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_16_1 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_16_10 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_16_11 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_16_12 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_16_13 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_16_14 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_16_15 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_16_16 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_16_17 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_16_18 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_16_19 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_16_2 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_16_20 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_16_21 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_16_22 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_16_23 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_16_24 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_16_25 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_16_26 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_16_27 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_16_28 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_16_29 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_16_3 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_16_30 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_16_31 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_16_32 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_16_33 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_16_34 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_16_35 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_16_36 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_16_4 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_16_5 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_16_6 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_16_7 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_16_8 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_16_9 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_17_0 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_17_1 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_17_10 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_17_11 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_17_12 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_17_13 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_17_14 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_17_15 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_17_16 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_17_17 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_17_18 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_17_19 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_17_2 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_17_20 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_17_21 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_17_22 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_17_23 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_17_24 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_17_25 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_17_26 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_17_27 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_17_28 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_17_29 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_17_3 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_17_30 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_17_31 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_17_32 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_17_33 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_17_34 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_17_35 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_17_36 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_17_37 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_17_4 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_17_5 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_17_6 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_17_7 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_17_8 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_17_9 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_18_0 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_18_1 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_18_10 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_18_11 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_18_12 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_18_13 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_18_14 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_18_15 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_18_16 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_18_17 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_18_18 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_18_19 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_18_2 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_18_20 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_18_21 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_18_22 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_18_23 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_18_24 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_18_25 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_18_26 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_18_27 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_18_28 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_18_29 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_18_3 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_18_30 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_18_31 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_18_32 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_18_33 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_18_34 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_18_35 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_18_36 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_18_4 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_18_5 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_18_6 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_18_7 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_18_8 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_18_9 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_19_0 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_19_1 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_19_10 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_19_11 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_19_12 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_19_13 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_19_14 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_19_15 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_19_16 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_19_17 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_19_18 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_19_19 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_19_2 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_19_20 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_19_21 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_19_22 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_19_23 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_19_24 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_19_25 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_19_26 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_19_27 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_19_28 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_19_29 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_19_3 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_19_30 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_19_31 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_19_32 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_19_33 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_19_34 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_19_35 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_19_36 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_19_37 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_19_4 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_19_5 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_19_6 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_19_7 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_19_8 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_19_9 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_1_0 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_1_1 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_1_10 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_1_11 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_1_12 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_1_13 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_1_14 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_1_15 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_1_16 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_1_17 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_1_18 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_1_19 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_1_2 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_1_20 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_1_21 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_1_22 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_1_23 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_1_24 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_1_25 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_1_26 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_1_27 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_1_28 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_1_29 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_1_3 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_1_30 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_1_31 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_1_32 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_1_33 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_1_34 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_1_35 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_1_36 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_1_37 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_1_4 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_1_5 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_1_6 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_1_7 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_1_8 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_1_9 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_20_0 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_20_1 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_20_10 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_20_11 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_20_12 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_20_13 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_20_14 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_20_15 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_20_16 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_20_17 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_20_18 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_20_19 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_20_2 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_20_20 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_20_21 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_20_22 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_20_23 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_20_24 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_20_25 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_20_26 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_20_27 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_20_28 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_20_29 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_20_3 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_20_30 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_20_31 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_20_32 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_20_33 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_20_34 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_20_35 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_20_36 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_20_4 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_20_5 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_20_6 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_20_7 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_20_8 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_20_9 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_21_0 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_21_1 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_21_10 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_21_11 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_21_12 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_21_13 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_21_14 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_21_15 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_21_16 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_21_17 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_21_18 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_21_19 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_21_2 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_21_20 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_21_21 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_21_22 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_21_23 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_21_24 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_21_25 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_21_26 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_21_27 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_21_28 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_21_29 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_21_3 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_21_30 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_21_31 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_21_32 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_21_33 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_21_34 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_21_35 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_21_36 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_21_37 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_21_4 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_21_5 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_21_6 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_21_7 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_21_8 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_21_9 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_22_0 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_22_1 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_22_10 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_22_11 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_22_12 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_22_13 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_22_14 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_22_15 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_22_16 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_22_17 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_22_18 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_22_19 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_22_2 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_22_20 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_22_21 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_22_22 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_22_23 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_22_24 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_22_25 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_22_26 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_22_27 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_22_28 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_22_29 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_22_3 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_22_30 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_22_31 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_22_32 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_22_33 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_22_34 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_22_35 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_22_36 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_22_4 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_22_5 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_22_6 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_22_7 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_22_8 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_22_9 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_23_0 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_23_1 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_23_10 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_23_11 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_23_12 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_23_13 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_23_14 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_23_15 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_23_16 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_23_17 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_23_18 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_23_19 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_23_2 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_23_20 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_23_21 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_23_22 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_23_23 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_23_24 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_23_25 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_23_26 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_23_27 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_23_28 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_23_29 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_23_3 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_23_30 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_23_31 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_23_32 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_23_33 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_23_34 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_23_35 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_23_36 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_23_37 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_23_4 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_23_5 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_23_6 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_23_7 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_23_8 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_23_9 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_24_0 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_24_1 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_24_10 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_24_11 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_24_12 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_24_13 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_24_14 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_24_15 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_24_16 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_24_17 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_24_18 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_24_19 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_24_2 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_24_20 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_24_21 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_24_22 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_24_23 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_24_24 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_24_25 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_24_26 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_24_27 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_24_28 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_24_29 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_24_3 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_24_30 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_24_31 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_24_32 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_24_33 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_24_34 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_24_35 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_24_36 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_24_4 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_24_5 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_24_6 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_24_7 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_24_8 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_24_9 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_25_0 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_25_1 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_25_10 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_25_11 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_25_12 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_25_13 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_25_14 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_25_15 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_25_16 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_25_17 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_25_18 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_25_19 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_25_2 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_25_20 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_25_21 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_25_22 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_25_23 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_25_24 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_25_25 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_25_26 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_25_27 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_25_28 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_25_29 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_25_3 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_25_30 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_25_31 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_25_32 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_25_33 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_25_34 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_25_35 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_25_36 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_25_37 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_25_4 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_25_5 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_25_6 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_25_7 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_25_8 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_25_9 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_26_0 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_26_1 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_26_10 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_26_11 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_26_12 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_26_13 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_26_14 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_26_15 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_26_16 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_26_17 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_26_18 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_26_19 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_26_2 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_26_20 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_26_21 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_26_22 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_26_23 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_26_24 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_26_25 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_26_26 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_26_27 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_26_28 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_26_29 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_26_3 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_26_30 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_26_31 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_26_32 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_26_33 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_26_34 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_26_35 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_26_36 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_26_4 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_26_5 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_26_6 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_26_7 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_26_8 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_26_9 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_27_0 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_27_1 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_27_10 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_27_11 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_27_12 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_27_13 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_27_14 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_27_15 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_27_16 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_27_17 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_27_18 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_27_19 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_27_2 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_27_20 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_27_21 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_27_22 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_27_23 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_27_24 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_27_25 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_27_26 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_27_27 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_27_28 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_27_29 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_27_3 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_27_30 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_27_31 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_27_32 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_27_33 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_27_34 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_27_35 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_27_36 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_27_37 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_27_4 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_27_5 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_27_6 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_27_7 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_27_8 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_27_9 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_28_0 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_28_1 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_28_10 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_28_11 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_28_12 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_28_13 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_28_14 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_28_15 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_28_16 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_28_17 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_28_18 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_28_19 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_28_2 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_28_20 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_28_21 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_28_22 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_28_23 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_28_24 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_28_25 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_28_26 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_28_27 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_28_28 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_28_29 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_28_3 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_28_30 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_28_31 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_28_32 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_28_33 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_28_34 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_28_35 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_28_36 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_28_4 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_28_5 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_28_6 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_28_7 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_28_8 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_28_9 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_29_0 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_29_1 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_29_10 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_29_11 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_29_12 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_29_13 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_29_14 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_29_15 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_29_16 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_29_17 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_29_18 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_29_19 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_29_2 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_29_20 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_29_21 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_29_22 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_29_23 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_29_24 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_29_25 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_29_26 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_29_27 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_29_28 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_29_29 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_29_3 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_29_30 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_29_31 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_29_32 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_29_33 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_29_34 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_29_35 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_29_36 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_29_37 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_29_4 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_29_5 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_29_6 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_29_7 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_29_8 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_29_9 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_2_0 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_2_1 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_2_10 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_2_11 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_2_12 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_2_13 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_2_14 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_2_15 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_2_16 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_2_17 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_2_18 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_2_19 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_2_2 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_2_20 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_2_21 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_2_22 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_2_23 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_2_24 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_2_25 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_2_26 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_2_27 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_2_28 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_2_29 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_2_3 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_2_30 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_2_31 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_2_32 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_2_33 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_2_34 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_2_35 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_2_36 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_2_4 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_2_5 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_2_6 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_2_7 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_2_8 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_2_9 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_30_0 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_30_1 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_30_10 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_30_11 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_30_12 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_30_13 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_30_14 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_30_15 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_30_16 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_30_17 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_30_18 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_30_19 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_30_2 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_30_20 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_30_21 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_30_22 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_30_23 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_30_24 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_30_25 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_30_26 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_30_27 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_30_28 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_30_29 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_30_3 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_30_30 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_30_31 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_30_32 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_30_33 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_30_34 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_30_35 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_30_36 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_30_4 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_30_5 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_30_6 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_30_7 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_30_8 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_30_9 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_31_0 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_31_1 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_31_10 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_31_11 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_31_12 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_31_13 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_31_14 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_31_15 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_31_16 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_31_17 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_31_18 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_31_19 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_31_2 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_31_20 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_31_21 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_31_22 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_31_23 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_31_24 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_31_25 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_31_26 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_31_27 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_31_28 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_31_29 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_31_3 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_31_30 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_31_31 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_31_32 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_31_33 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_31_34 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_31_35 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_31_36 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_31_37 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_31_4 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_31_5 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_31_6 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_31_7 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_31_8 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_31_9 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_32_0 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_32_1 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_32_10 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_32_11 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_32_12 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_32_13 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_32_14 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_32_15 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_32_16 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_32_17 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_32_18 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_32_19 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_32_2 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_32_20 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_32_21 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_32_22 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_32_23 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_32_24 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_32_25 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_32_26 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_32_27 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_32_28 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_32_29 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_32_3 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_32_30 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_32_31 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_32_32 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_32_33 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_32_34 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_32_35 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_32_36 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_32_4 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_32_5 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_32_6 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_32_7 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_32_8 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_32_9 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_33_0 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_33_1 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_33_10 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_33_11 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_33_12 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_33_13 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_33_14 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_33_15 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_33_16 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_33_17 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_33_18 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_33_19 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_33_2 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_33_20 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_33_21 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_33_22 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_33_23 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_33_24 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_33_25 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_33_26 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_33_27 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_33_28 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_33_29 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_33_3 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_33_30 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_33_31 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_33_32 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_33_4 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_33_5 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_33_6 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_33_7 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_33_8 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_33_9 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_34_0 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_34_1 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_34_10 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_34_11 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_34_12 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_34_13 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_34_14 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_34_15 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_34_16 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_34_17 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_34_18 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_34_19 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_34_2 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_34_20 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_34_21 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_34_22 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_34_23 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_34_24 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_34_25 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_34_26 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_34_27 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_34_3 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_34_4 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_34_5 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_34_6 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_34_7 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_34_8 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_34_9 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_3_0 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_3_1 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_3_10 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_3_11 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_3_12 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_3_13 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_3_14 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_3_15 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_3_16 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_3_17 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_3_18 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_3_19 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_3_2 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_3_20 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_3_21 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_3_22 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_3_23 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_3_24 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_3_25 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_3_26 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_3_27 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_3_28 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_3_29 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_3_3 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_3_30 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_3_31 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_3_32 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_3_33 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_3_34 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_3_35 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_3_36 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_3_37 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_3_4 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_3_5 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_3_6 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_3_7 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_3_8 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_3_9 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_4_0 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_4_1 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_4_10 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_4_11 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_4_12 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_4_13 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_4_14 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_4_15 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_4_16 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_4_17 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_4_18 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_4_19 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_4_2 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_4_20 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_4_21 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_4_22 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_4_23 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_4_24 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_4_25 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_4_26 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_4_27 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_4_28 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_4_29 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_4_3 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_4_30 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_4_31 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_4_32 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_4_33 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_4_34 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_4_35 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_4_36 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_4_4 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_4_5 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_4_6 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_4_7 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_4_8 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_4_9 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_5_0 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_5_1 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_5_10 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_5_11 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_5_12 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_5_13 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_5_14 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_5_15 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_5_16 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_5_17 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_5_18 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_5_19 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_5_2 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_5_20 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_5_21 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_5_22 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_5_23 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_5_24 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_5_25 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_5_26 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_5_27 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_5_28 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_5_29 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_5_3 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_5_30 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_5_31 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_5_32 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_5_33 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_5_34 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_5_35 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_5_36 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_5_37 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_5_4 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_5_5 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_5_6 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_5_7 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_5_8 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_5_9 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_6_0 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_6_1 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_6_10 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_6_11 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_6_12 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_6_13 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_6_14 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_6_15 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_6_16 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_6_17 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_6_18 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_6_19 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_6_2 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_6_20 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_6_21 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_6_22 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_6_23 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_6_24 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_6_25 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_6_26 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_6_27 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_6_28 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_6_29 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_6_3 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_6_30 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_6_31 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_6_32 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_6_33 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_6_34 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_6_35 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_6_36 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_6_4 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_6_5 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_6_6 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_6_7 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_6_8 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_6_9 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_7_0 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_7_1 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_7_10 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_7_11 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_7_12 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_7_13 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_7_14 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_7_15 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_7_16 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_7_17 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_7_18 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_7_19 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_7_2 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_7_20 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_7_21 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_7_22 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_7_23 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_7_24 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_7_25 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_7_26 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_7_27 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_7_28 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_7_29 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_7_3 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_7_30 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_7_31 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_7_32 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_7_33 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_7_34 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_7_35 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_7_36 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_7_37 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_7_4 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_7_5 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_7_6 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_7_7 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_7_8 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_7_9 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_8_0 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_8_1 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_8_10 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_8_11 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_8_12 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_8_13 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_8_14 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_8_15 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_8_16 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_8_17 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_8_18 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_8_19 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_8_2 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_8_20 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_8_21 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_8_22 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_8_23 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_8_24 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_8_25 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_8_26 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_8_27 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_8_28 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_8_29 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_8_3 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_8_30 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_8_31 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_8_32 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_8_33 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_8_34 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_8_35 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_8_36 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_8_4 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_8_5 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_8_6 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_8_7 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_8_8 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_8_9 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_9_0 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_9_1 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_9_10 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_9_11 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_9_12 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_9_13 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_9_14 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_9_15 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_9_16 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_9_17 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_9_18 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_9_19 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_9_2 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_9_20 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_9_21 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_9_22 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_9_23 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_9_24 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_9_25 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_9_26 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_9_27 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_9_28 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_9_29 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_9_3 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_9_30 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_9_31 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_9_32 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_9_33 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_9_34 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_9_35 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_9_36 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_9_37 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_9_4 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_9_5 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_9_6 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_9_7 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_9_8 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xtap_9_9 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
.ENDS
